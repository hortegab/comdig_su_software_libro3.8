<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Lab_total</value></param>
<param><key>author</key><value>Homero Ortega Boada</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
<param><key>title</key><value>Lab_total</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bps</value></param>
<param><key>value</key><value>int(math.log(M,2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>len(const)</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>MiconstellationObject</value></param>
<param><key>const_points</key><value>const[0].points()</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value></value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Nfdev</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>value</key><value>Rs*Bps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>samp_rate/Sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const</value></param>
<param><key>value</key><value>(digital.constellation_bpsk(), digital.constellation_qpsk(), digital.constellation_8psk(), digital.qam.qam_constellation(16))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>f_correccion</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@0:0,1,1,1</value></param>
<param><key>label</key><value>"correcion de frecuencia (FLL)"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-f_dev_max</value></param>
<param><key>step</key><value>f_dev_max*2/Nfdev</value></param>
<param><key>stop</key><value>f_dev_max</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_dev</value></param>
<param><key>value</key><value>numpy.linspace(-f_dev_max,f_dev_max,Nfdev+1 )</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_dev_max</value></param>
<param><key>value</key><value>1/10.</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fase_correccion</value></param>
<param><key>value</key><value>0.</value></param>
<param><key>gui_hint</key><value>controls@0:0,2,1,1</value></param>
<param><key>label</key><value>"correcion de Fase (PLL)"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-math.pi</value></param>
<param><key>step</key><value>2.*math.pi/100.</value></param>
<param><key>stop</key><value>math.pi</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>controls@0:0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>E3TRadio_zero_order_hold2_cc</key>
<param><key>id</key><value>E3TRadio_zero_order_hold2_cc_0</value></param>
<param><key>k</key><value>Sps</value></param>
</block>
<block>
<key>E3TRadio_zero_order_hold2_cc</key>
<param><key>id</key><value>E3TRadio_zero_order_hold2_cc_0_0</value></param>
<param><key>k</key><value>Sps</value></param>
</block>
<block>
<key>b_symb_source</key>
<param><key>id</key><value>b_symb_source_0</value></param>
<param><key>Constelacion</key><value>MiconstellationObject.points()</value></param>
</block>
<block>
<key>b_upconverter_cf</key>
<param><key>id</key><value>b_upconverter_cf_0</value></param>
<param><key>Fc</key><value>Rs</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>b_upconverter_cf</key>
<param><key>id</key><value>b_upconverter_cf_0_0</value></param>
<param><key>Fc</key><value>Rs</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>numpy.exp(1.j*math.pi/2.)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>controls</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>label0</key><value>Correccion para FLL y PLL</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from random import randint, uniform</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import  numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>En fase</value></param>
<param><key>width1</key><value>4</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Desfasada</value></param>
<param><key>width2</key><value>4</value></param>
<param><key>name</key><value>"senal BPSK"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>256</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>width1</key><value>4</value></param>
<param><key>name</key><value>"Senal BPSK desfasada"</value></param>
<param><key>size</key><value>256</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<connection><source_block_id>E3TRadio_zero_order_hold2_cc_0</source_block_id><sink_block_id>b_upconverter_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_zero_order_hold2_cc_0_0</source_block_id><sink_block_id>b_upconverter_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_symb_source_0</source_block_id><sink_block_id>E3TRadio_zero_order_hold2_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_symb_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_upconverter_cf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_upconverter_cf_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_upconverter_cf_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>E3TRadio_zero_order_hold2_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
