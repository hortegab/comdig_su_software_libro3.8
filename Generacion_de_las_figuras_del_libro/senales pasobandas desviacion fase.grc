options:
  parameters:
    author: Homero Ortega Boada
    category: Custom
    generate_options: qt_gui
    id: Lab_total
    output_language: python
    run: run_stop
    title: Lab_total
  states: {}

blocks:
- name: Bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: M
  id: variable
  parameters:
    value: len(const)
  states: {}
- name: MiconstellationObject
  id: variable_constellation
  parameters:
    const_points: const[0].points()
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: numpy.arange(len(const[0].points()))
    type: calcdist
  states: {}
- name: Nfdev
  id: variable
  parameters:
    value: '32'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*Bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: const
  id: variable
  parameters:
    value: (digital.constellation_bpsk(), digital.constellation_qpsk(), digital.constellation_8psk(), digital.qam.qam_constellation(16))
  states: {}
- name: f_correccion
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@0:0,1,1,1
    label: '"correcion de frecuencia (FLL)"'
    start: '-f_dev_max'
    step: f_dev_max*2/Nfdev
    stop: f_dev_max
    value: '0'
  states: {}
- name: f_dev
  id: variable
  parameters:
    value: numpy.linspace(-f_dev_max,f_dev_max,Nfdev+1 )
  states: {}
- name: f_dev_max
  id: variable
  parameters:
    value: 1/10.
  states: {}
- name: fase_correccion
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@0:0,2,1,1
    label: '"correcion de Fase (PLL)"'
    start: '-math.pi'
    step: 2.*math.pi/100.
    stop: math.pi
    value: '0.'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: controls@0:0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: E3TRadio_zero_order_hold2_cc_0
  id: E3TRadio_zero_order_hold2_cc
  parameters:
    k: Sps
  states: {}
- name: E3TRadio_zero_order_hold2_cc_0_0
  id: E3TRadio_zero_order_hold2_cc
  parameters:
    k: Sps
  states: {}
- name: b_symb_source_0
  id: b_symb_source
  parameters:
    Constelacion: MiconstellationObject.points()
  states: {}
- name: b_upconverter_cf_0
  id: b_upconverter_cf
  parameters:
    Fc: Rs
    samp_rate: samp_rate
  states: {}
- name: b_upconverter_cf_0_0
  id: b_upconverter_cf
  parameters:
    Fc: Rs
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.exp(1.j*math.pi/2.)
    type: complex
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Correccion para FLL y PLL
    num_tabs: '1'
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from random import randint, uniform
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import  numpy
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import random
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: En fase
    label2: Desfasada
    name: '"senal BPSK"'
    nconnections: '2'
    size: '256'
    srate: samp_rate
    type: float
    width1: '4'
    width2: '4'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,1
    label1: ''
    name: '"Senal BPSK desfasada"'
    size: '256'
    srate: samp_rate
    type: float
    width1: '4'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [E3TRadio_zero_order_hold2_cc_0, '0', b_upconverter_cf_0, '0']
- [E3TRadio_zero_order_hold2_cc_0_0, '0', b_upconverter_cf_0_0, '0']
- [b_symb_source_0, '0', E3TRadio_zero_order_hold2_cc_0, '0']
- [b_symb_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [b_upconverter_cf_0, '0', qtgui_time_sink_x_0, '0']
- [b_upconverter_cf_0_0, '0', qtgui_time_sink_x_0, '1']
- [b_upconverter_cf_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', E3TRadio_zero_order_hold2_cc_0_0, '0']

metadata:
  file_format: 1
