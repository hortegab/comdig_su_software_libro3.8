options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: Lab_total
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: Ajuste_phi
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@0:0,2,1,1
    label: Ch_Desajuste_phi (Rad)
    start: '-2.*math.pi'
    step: 4*math.pi/200.
    stop: 2.*math.pi
    value: '0.'
    widget: counter
  states: {}
- name: Bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Ch_Fluct_percent
  id: variable
  parameters:
    value: '10.'
  states: {}
- name: Constelacion
  id: variable
  parameters:
    value: digital.constellation_8psk().points()
  states: {state: disabled}
- name: Constelacion
  id: variable
  parameters:
    value: digital.constellation_16qam().points()
  states: {state: disabled}
- name: Constelacion
  id: variable
  parameters:
    value: '[1.+0.j,   0.+1.j,   -1.+0.j,  0.-1.j ]'
  states: {state: disabled}
- name: Constelacion
  id: variable
  parameters:
    value: '[1.+0.j, -1.+0.j,  ]'
  states: {state: disabled}
- name: Constelacion
  id: variable
  parameters:
    value: '[(1+1.j)/4.24,(3+1.j)/4.24,(3+3.j)/4.24,(1+3.j)/4.24,(-1+1.j)/4.24,(-3+1.j)/4.24,(-3+3.j)/4.24,(-1+3.j)/4.24,(-1-1.j)/4.24,(-3-1.j)/4.24,(-3-3.j)/4.24,(-1-3.j)/4.24,(1-1.j)/4.24,(3-1.j)/4.24,(3-3.j)/4.24,(1-3.j)/4.24]'
  states: {state: disabled}
- name: Constelacion
  id: variable
  parameters:
    value: '[1.+0.j,        0.7071+ 0.7071j,        0.+1.j,        -0.7071+ 0.7071j,        -1.+0.j,            -0.7071-0.7071j,        0.-1.j,         0.7071- 0.7071j ]'
  states: {state: disabled}
- name: Constelacion
  id: variable
  parameters:
    value: digital.constellation_bpsk().points()
  states: {state: disabled}
- name: Constelacion
  id: variable
  parameters:
    value: digital.constellation_qpsk().points()
  states: {}
- name: F_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@0:0,1,1,1
    label: Ch_Frec_offset (Hz)
    start: '-100'
    step: '0.01'
    stop: '100'
    value: '0'
    widget: counter
  states: {}
- name: Fc
  id: variable
  parameters:
    value: 80e6
  states: {}
- name: Kd
  id: variable
  parameters:
    value: math.pow(2,m1)
  states: {}
- name: Kd_d
  id: variable
  parameters:
    value: samp_rate_usrp_rx/samp_rate_d
  states: {}
- name: Ki
  id: variable
  parameters:
    value: math.pow(2,m)
  states: {}
- name: Ki_d
  id: variable
  parameters:
    value: samp_rate_usrp_tx/samp_rate_d
  states: {}
- name: M
  id: variable
  parameters:
    value: len(Constelacion)
  states: {}
- name: MiconstellationObject
  id: variable_constellation
  parameters:
    const_points: Constelacion
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: numpy.arange(M)
    type: calcdist
  states: {}
- name: NbpS
  id: variable
  parameters:
    value: '4'
  states: {}
- name: NnivelesQ
  id: variable
  parameters:
    value: int(math.pow(2,NbpS))
  states: {}
- name: NodB
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@0:0,3,1,1
    label: Ch Noise dB
    start: '-100'
    step: '1'
    stop: '100'
    value: '-60.'
    widget: counter
  states: {}
- name: Path_Loss_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@0:0,4,1,1
    label: Ch_Path_Loss_dB
    start: '-100'
    step: '1'
    stop: '100'
    value: '0.'
    widget: counter
  states: {}
- name: Rb
  id: variable
  parameters:
    value: NbpS*samp_rate_audio
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/Bps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: SymbTune
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@1:0,0,1,1
    label: SymbTunning
    rangeType: int
    start: '0'
    step: '1'
    stop: '1000'
    value: '0'
    widget: counter
  states: {}
- name: Tmax_scope
  id: variable
  parameters:
    value: 16./Rs
  states: {}
- name: Vp
  id: variable
  parameters:
    value: '1.'
  states: {}
- name: m
  id: variable
  parameters:
    value: math.floor(math.log(Ki_d,2))
  states: {}
- name: m1
  id: variable
  parameters:
    value: math.floor(math.log(Kd_d,2))
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(samp_rate_usrp_rx/Kd)
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '11000'
  states: {}
- name: samp_rate_d
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: int(samp_rate_usrp_tx/Ki)
  states: {}
- name: samp_rate_usrp_rx
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: samp_rate_usrp_tx
  id: variable
  parameters:
    value: 400e6
  states: {}
- name: Tx_1_0
  id: virtual_sink
  parameters:
    stream_id: T8
  states: {}
- name: Tx_1_0_0
  id: virtual_sink
  parameters:
    stream_id: T7
  states: {}
- name: Tx_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R8
  states: {}
- name: Tx_1_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R7
  states: {}
- name: Tx_1_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: R3
  states: {}
- name: Tx_1_0_0_2
  id: virtual_sink
  parameters:
    stream_id: T3
  states: {}
- name: Tx_3
  id: virtual_sink
  parameters:
    stream_id: T1
  states: {}
- name: Tx_3_0
  id: virtual_sink
  parameters:
    stream_id: R1
  states: {state: disabled}
- name: Tx_3_0_0
  id: virtual_sink
  parameters:
    stream_id: R0
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_audio
  states: {state: disabled}
- name: b_Canal_simple_cc_0
  id: b_Canal_simple_cc
  parameters:
    Ch_Loss_dB: Path_Loss_dB
    Ch_NodB: NodB
    Ch_Phoffset: Ajuste_phi
    Ch_Toffset: '0'
    Fluctuacion: Ch_Fluct_percent
    Foffset: F_offset
    N_fluct: '1'
    samp_rate: Rs
  states: {}
- name: b_quantizer_fb_0
  id: b_quantizer_fb
  parameters:
    NivelesQ: NnivelesQ
    Vmax: Vp
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: SymbTune
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '16'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Vp/(NnivelesQ/2)
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/MisGits/comdig_su_software_libro3.8/Generacion_de_las_figuras_del_libro/bush-clinton_debate_waffle.wav
    repeat: 'True'
  states: {}
- name: canal
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constelaciones
    label1: Tiempo
    num_tabs: '2'
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,2
    label0: Manipulacion parametros del Canal
    label1: Sintonizar parametros de otros bloques
    num_tabs: '2'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: Constelacion
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject
  states: {}
- name: e1_0_0_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: R0
  states: {state: disabled}
- name: e1_0_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: T1
  states: {state: disabled}
- name: e1_0_0_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: T8
  states: {}
- name: e1_0_0_0_1_1_0_0
  id: virtual_source
  parameters:
    stream_id: T7
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_1_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_1_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    note: CAPA8 MENSAJE
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: CAPA7 CUANTIFICACION
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: CAPA3 M-PAM
  states: {}
- name: note_0_0_0_0_0
  id: note
  parameters:
    note: CAPA1 MODULACION
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: CAPA0 CANAL
  states: {}
- name: note_0_0_1_2
  id: note
  parameters:
    note: INSTRUMENTACION
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'SIGLAS Y VARIABLES: https://docs.google.com/document/d/19AjAUNqbtj1wffUuGf1V54hHX_k6hvU3wvFGbyFYviE/edit#bookmark=id.mnniv0n51crf'
  states: {}
- name: qtgui_const_sink_x_0_2_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"red"'
    gui_hint: canal@0:2,0,1,1
    label1: '"Tx.Modulador-salida                                                             "'
    name: ''
    size: '1024'
    type: complex
    width1: '4'
    xmax: '2.0'
    xmin: '-2.0'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_2_0_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"green"'
    gui_hint: canal@0:1,0,1,1
    label1: '"Salida del canal                                                                         "'
    name: ''
    size: '1024'
    type: complex
    xmax: '2.0'
    xmin: '-2.0'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: canal@0:1,0,1,1
    label1: ''
    marker1: '0'
    size: '128'
    srate: samp_rate_audio
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: canal@0:2,0,1,1
    label1: Salida del ADC
    label2: Re-cuantificada
    marker2: '0'
    nconnections: '2'
    size: '64'
    srate: samp_rate_audio
    style1: '3'
    type: float
    width1: '4'
    ymax: '16'
    ymin: '-16'
  states: {}

connections:
- [b_Canal_simple_cc_0, '0', Tx_3_0_0, '0']
- [b_Canal_simple_cc_0, '0', blocks_delay_0, '0']
- [b_quantizer_fb_0, '0', Tx_1_0_0, '0']
- [b_quantizer_fb_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_delay_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', Tx_1_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_null_sink_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', Tx_1_0_0_2, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', Tx_1_0_0_1, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_wavfile_source_0, '0', Tx_1_0, '0']
- [blocks_wavfile_source_0, '0', b_quantizer_fb_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', Tx_3, '0']
- [digital_chunks_to_symbols_xx_0, '0', b_Canal_simple_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', Tx_1_0_0_1_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [e1_0_0_0_1_0_0_0, '0', qtgui_const_sink_x_0_2_0_0, '0']
- [e1_0_0_0_1_1, '0', qtgui_const_sink_x_0_2_0, '0']
- [e1_0_0_0_1_1_0, '0', blocks_multiply_const_vxx_0, '0']
- [e1_0_0_0_1_1_0_0, '0', blocks_char_to_float_1, '0']

metadata:
  file_format: 1
