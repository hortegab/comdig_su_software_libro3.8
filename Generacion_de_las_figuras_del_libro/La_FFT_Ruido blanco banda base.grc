options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: B
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: BW
  id: variable
  parameters:
    value: B/2
  states: {}
- name: Fs2
  id: variable
  parameters:
    value: int(samp_rate*1.5)
  states: {}
- name: 'No'
  id: variable
  parameters:
    value: math.pow(10,No_dB/10.)
  states: {}
- name: No_dB
  id: variable
  parameters:
    value: '-40'
  states: {}
- name: P
  id: variable
  parameters:
    value: No*2*BW
  states: {}
- name: Vrms
  id: variable
  parameters:
    value: math.sqrt(P)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2*BW
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: Vrms
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2,1,1,1
    label1: '.'
    legend: 'False'
    name: '"D.Polar. Ruido Blanco Banda Base"'
    size: '1024'
    type: complex
    width1: '3'
    xmax: '0.0003'
    xmin: '-0.0003'
    ymax: '0.0003'
    ymin: '-0.0003'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: Fs2
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    label1: '.'
    name: '"PSD. Ruido Blanco Banda Base"'
    showports: 'True'
    type: complex
    width1: '3'
    ymax: '-50'
    ymin: '-200'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: Fs2
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: T0
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: T0
  states: {}

connections:
- [analog_noise_source_x_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
