<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Lab_total</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Am</value></param>
<param><key>value</key><value>.8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bps</value></param>
<param><key>value</key><value>int(math.log(M,2))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Ch_Delay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@0:0,3,1,1</value></param>
<param><key>label</key><value>Ch_Delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Ch_Frec_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@0:0,1,1,1</value></param>
<param><key>label</key><value>Ch_Frec_offset (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Ch_Jitter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@0:0,2,1,1</value></param>
<param><key>label</key><value>Ch_Jitter</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-.001</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>.001</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ch_taps</value></param>
<param><key>value</key><value>fftpack.ifftshift(fftpack.ifft([tap0, tap1, tap2, tap3, tap4, tap5, tap6, tap7]))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[1.+0.j,    -1.+0.j ]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>value</key><value>[1.+0.j,   0.+1.j,   -1.+0.j,  0.-1.j ]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fc</value></param>
<param><key>value</key><value>80e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>len(Constelacion)</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>MiconstellationObject</value></param>
<param><key>const_points</key><value>Constelacion</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value></value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NbpCode</value></param>
<param><key>value</key><value>len(code1)+10.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NbpS</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NnivelesQ</value></param>
<param><key>value</key><value>math.pow(2,NbpS)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>NodB</value></param>
<param><key>value</key><value>-80</value></param>
<param><key>gui_hint</key><value>controls@0:0,0,1,1</value></param>
<param><key>label</key><value>Ch_No(dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-140.</value></param>
<param><key>step</key><value>1.</value></param>
<param><key>stop</key><value>0.</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>value</key><value>Rbi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rbi</value></param>
<param><key>value</key><value>NbpS*samp_rate_audio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>Rb/Bps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps_o</value></param>
<param><key>value</key><value>Sps</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>SymbTune</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>controls@2:0,1,1,1</value></param>
<param><key>label</key><value>SymbTunning</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>TimingDelay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@2:0,0,1,1</value></param>
<param><key>label</key><value>Manual Timing</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Sps-1</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Tmax_scope</value></param>
<param><key>value</key><value>64./Rs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vp</value></param>
<param><key>value</key><value>1.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>W</value></param>
<param><key>value</key><value>Rs/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>code1</value></param>
<param><key>value</key><value>'010110011011101100010101011111101001001110001011010001101010001'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eq_gain</value></param>
<param><key>value</key><value>0.01</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>Sps*16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>value</key><value>0.9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps_rx</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(Sps), rolloff, ntaps*nfilts)</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>Rs*Sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_audio</value></param>
<param><key>value</key><value>11000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tap0</value></param>
<param><key>value</key><value>0.25</value></param>
<param><key>gui_hint</key><value>controls@1:0,0,1,1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tap1</value></param>
<param><key>value</key><value>0.05</value></param>
<param><key>gui_hint</key><value>controls@1:0,1,1,1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tap2</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>controls@1:0,2,1,1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0.25</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tap3</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>controls@1:0,3,1,1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tap4</value></param>
<param><key>value</key><value>0.25</value></param>
<param><key>gui_hint</key><value>controls@1:1,0,1,1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tap5</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>controls@1:1,1,1,1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tap6</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>controls@1:1,2,1,1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0.25</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tap7</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>controls@1:1,3,1,1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Instrumentos</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>label0</key><value>Capa0.Canal y precanal</value></param>
<param><key>label1</key><value>Capas.Pre-modulacion</value></param>
<param><key>label2</key><value>Capa1. Modulacion</value></param>
<param><key>label3</key><value>Capa2. CodificacionDeSimbolos</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Pre_modulacion</value></param>
<param><key>gui_hint</key><value>Instrumentos@1:1,0,1,1</value></param>
<param><key>label0</key><value>Capa8.Mensaje continuo</value></param>
<param><key>label1</key><value>Capa7.Cuantificacion</value></param>
<param><key>label2</key><value>Capa6.PCM</value></param>
<param><key>label3</key><value>Capa5.Otrastecnicas</value></param>
<param><key>label4</key><value>Capa4.CodificacionBinaria</value></param>
<param><key>label5</key><value>Capa3.M-PAM</value></param>
<param><key>num_tabs</key><value>6</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx</value></param>
<param><key>stream_id</key><value>T0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_0</value></param>
<param><key>stream_id</key><value>T2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>T3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>T8</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>T7</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>R8</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>R7</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>R6</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>T6</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_3</value></param>
<param><key>stream_id</key><value>T1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_3_0_0_0_0</value></param>
<param><key>stream_id</key><value>R1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_3_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>R1.1</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>M</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
</block>
<block>
<key>b_Eye_Diagram_simple_c</key>
<param><key>id</key><value>b_Eye_Diagram_simple_c_0</value></param>
<param><key>AlphaLineas</key><value>0.5</value></param>
<param><key>Delay_i</key><value>0</value></param>
<param><key>gui_hint</key><value>canal@1:1,0,1,1</value></param>
<param><key>GrosorLineas</key><value>20</value></param>
<param><key>Kint</key><value>1</value></param>
<param><key>N_eyes</key><value>2</value></param>
<param><key>Samprate1</key><value>samp_rate</value></param>
<param><key>Sps1</key><value>Sps</value></param>
<param><key>Title</key><value>"salida del canal"</value></param>
<param><key>Ymax</key><value>2</value></param>
<param><key>Ymin</key><value>-2</value></param>
</block>
<block>
<key>b_Eye_Diagram_simple_c</key>
<param><key>id</key><value>b_Eye_Diagram_simple_c_0_0</value></param>
<param><key>AlphaLineas</key><value>0.5</value></param>
<param><key>Delay_i</key><value>0</value></param>
<param><key>gui_hint</key><value>canal@2:1,0,1,1</value></param>
<param><key>GrosorLineas</key><value>20</value></param>
<param><key>Kint</key><value>1</value></param>
<param><key>N_eyes</key><value>2</value></param>
<param><key>Samprate1</key><value>samp_rate</value></param>
<param><key>Sps1</key><value>Sps</value></param>
<param><key>Title</key><value>"Entrada del ecualizador"</value></param>
<param><key>Ymax</key><value>2</value></param>
<param><key>Ymin</key><value>-2</value></param>
</block>
<block>
<key>b_M_PAM_bb</key>
<param><key>id</key><value>b_M_PAM_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>b_RRaised_cosine_cc</key>
<param><key>id</key><value>b_RRaised_cosine_cc_0</value></param>
<param><key>Ganancia</key><value>1.</value></param>
<param><key>Interpolation</key><value>Sps</value></param>
<param><key>ntaps</key><value>ntaps*Sps</value></param>
<param><key>rolloff</key><value>rolloff</value></param>
<param><key>sps</key><value>Sps</value></param>
</block>
<block>
<key>b_de_M_PAM_bb</key>
<param><key>id</key><value>b_de_M_PAM_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>b_de_M_PAM_bb</key>
<param><key>id</key><value>b_de_M_PAM_bb_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>b_quantizer_fb</key>
<param><key>id</key><value>b_quantizer_fb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>NivelesQ</key><value>NnivelesQ</value></param>
<param><key>Vmax</key><value>Vp</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>SymbTune*Bps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>Ch_Delay*Sps</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1</value></param>
<param><key>delay</key><value>SymbTune*Bps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>Vp/(NnivelesQ/2)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0</value></param>
<param><key>const</key><value>Vp/(NnivelesQ/2)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>NbpS</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>NbpS</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate_audio</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>NbpS</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/comdig1/Dropbox/EnUbuntuFull/ClaseComDig/LibroAplicativos/Capitilo 2/Lab2.4/bush-clinton_debate_waffle.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>canal</value></param>
<param><key>gui_hint</key><value>Instrumentos@0:1,0,1,1</value></param>
<param><key>label0</key><value>H(f) y Espectro</value></param>
<param><key>label1</key><value>Diagrama de ojo canal</value></param>
<param><key>label2</key><value>Diagrama de ojo ecualizador</value></param>
<param><key>label3</key><value>Constelacion</value></param>
<param><key>label4</key><value>La Ecualizacion</value></param>
<param><key>num_tabs</key><value>5</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>Ch_Jitter+1.</value></param>
<param><key>freq_offset</key><value>Ch_Frec_offset</value></param>
<param><key>noise_voltage</key><value>math.pow(10.,(NodB)/20.)</value></param>
<param><key>seed</key><value>13</value></param>
<param><key>taps</key><value>Ch_taps</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>controls</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label0</key><value>Ch_Offsets</value></param>
<param><key>label1</key><value>Ch_Taps</value></param>
<param><key>label2</key><value>Tuning</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>Constelacion</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>MiconstellationObject</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0_0</value></param>
<param><key>constellation</key><value>MiconstellationObject</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>modulus</key><value>M</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>modulus</key><value>M</value></param>
</block>
<block>
<key>digital_diff_encoder_bb</key>
<param><key>id</key><value>digital_diff_encoder_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>modulus</key><value>M</value></param>
</block>
<block>
<key>digital_lms_dd_equalizer_cc</key>
<param><key>id</key><value>digital_lms_dd_equalizer_cc_0</value></param>
<param><key>cnst</key><value>MiconstellationObject</value></param>
<param><key>mu</key><value>eq_gain</value></param>
<param><key>num_taps</key><value>11</value></param>
<param><key>sps</key><value>Sps_o</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>2*math.pi/100.0</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>Sps_o</value></param>
<param><key>sps</key><value>Sps</value></param>
<param><key>taps</key><value>rrc_taps_rx</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>2*math.pi/100.0</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>Sps</value></param>
<param><key>taps</key><value>rrc_taps_rx</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_1_0_0_0_0_1</value></param>
<param><key>stream_id</key><value>T1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_1_0_0_0_0_1_0</value></param>
<param><key>stream_id</key><value>R1.1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_1_0_0_0_0_1_0_0</value></param>
<param><key>stream_id</key><value>R0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_1_0_0_0_0_1_0_0_0</value></param>
<param><key>stream_id</key><value>R0.1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_1_0_0_0_0_1_0_1</value></param>
<param><key>stream_id</key><value>R1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_1_0_0_0_0_1_0_1_0</value></param>
<param><key>stream_id</key><value>R0.1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_1_0_0_0_0_1_0_1_0_0</value></param>
<param><key>stream_id</key><value>R1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_scipy</value></param>
<param><key>import</key><value>from scipy import fftpack</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>CAPA8 MENSAJE</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>CAPA7 CUANTIFICACION</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>CAPA3 M-PAM</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>CAPA2 DIF.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0</value></param>
<param><key>note</key><value>CAPA1 MODULACION</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0_0</value></param>
<param><key>note</key><value>CAPA0.1 PRECANAL</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>CAPA6-PCM</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_1</value></param>
<param><key>note</key><value>CAPA0 CANAL</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_1_2</value></param>
<param><key>note</key><value>INSTRUMENTACION</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_1_1</value></param>
<param><key>gui_hint</key><value>canal@3:1,0,1,1</value></param>
<param><key>label1</key><value>Entrada de canal</value></param>
<param><key>label2</key><value>Salida del Canal</value></param>
<param><key>name</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_1_1_0</value></param>
<param><key>gui_hint</key><value>canal@3:1,1,1,1</value></param>
<param><key>label1</key><value>Salida del Ecualizador</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_1_1_0_0</value></param>
<param><key>gui_hint</key><value>canal@4:0,0,1,1</value></param>
<param><key>label1</key><value>Equalizer input</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_1_1_0_0_0</value></param>
<param><key>gui_hint</key><value>canal@4:0,1,1,1</value></param>
<param><key>label1</key><value>Equalizer output</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_1</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>Rs</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>canal@0:1,0,1,1</value></param>
<param><key>label1</key><value>Entrada del canal</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>label2</key><value>salida del canal</value></param>
<param><key>name</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_1_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>Rs*Sps_o</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>canal@4:1,0,1,1</value></param>
<param><key>label1</key><value>Equalizer input</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>name</key><value></value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>label</key><value>H(f)</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_1_0_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>Rs</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>canal@4:1,1,1,1</value></param>
<param><key>label1</key><value>Equalizer output</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>name</key><value></value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>label</key><value>H(f)</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>Rs</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>canal@0:1,1,1,1</value></param>
<param><key>int_max</key><value>-30</value></param>
<param><key>int_min</key><value>-50</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>s1_1_0</value></param>
<param><key>stream_id</key><value>R0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>s1_1_0_0</value></param>
<param><key>stream_id</key><value>R2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>s1_1_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>R3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>s1_1_0_1</value></param>
<param><key>stream_id</key><value>R0.1</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>s1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>Tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_M_PAM_bb_0</source_block_id><sink_block_id>Tx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_M_PAM_bb_0</source_block_id><sink_block_id>digital_diff_encoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_RRaised_cosine_cc_0</source_block_id><sink_block_id>Tx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_RRaised_cosine_cc_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_M_PAM_bb_0</source_block_id><sink_block_id>Tx_1_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_M_PAM_bb_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_M_PAM_bb_0_0</source_block_id><sink_block_id>blocks_delay_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_quantizer_fb_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>Tx_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>Tx_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>Tx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_1</source_block_id><sink_block_id>Tx_1_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_1</source_block_id><sink_block_id>b_M_PAM_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>Tx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>b_quantizer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>Tx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>b_RRaised_cosine_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>s1_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>b_de_M_PAM_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>s1_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0_0</source_block_id><sink_block_id>b_de_M_PAM_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_encoder_bb_0</source_block_id><sink_block_id>Tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_encoder_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_lms_dd_equalizer_cc_0</source_block_id><sink_block_id>Tx_3_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_lms_dd_equalizer_cc_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_lms_dd_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>s1_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0_0</source_block_id><sink_block_id>Tx_3_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0_1</source_block_id><sink_block_id>qtgui_const_sink_x_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0_1_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_1_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0_1_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0_1_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0_1_0_0</source_block_id><sink_block_id>b_Eye_Diagram_simple_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0_1_0_0_0</source_block_id><sink_block_id>b_Eye_Diagram_simple_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0_1_0_1</source_block_id><sink_block_id>qtgui_const_sink_x_0_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0_1_0_1_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_1_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0_1_0_1_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0_1_0_1_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_1_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0_1_0_1_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
