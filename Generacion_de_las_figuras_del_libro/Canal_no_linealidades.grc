options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: Lab_total
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: Am
  id: variable
  parameters:
    value: '.8'
  states: {}
- name: Bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Ch_Delay
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@0:0,3,1,1
    label: Ch_Delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '1000'
    value: '0'
    widget: counter
  states: {}
- name: Ch_Frec_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@0:0,1,1,1
    label: Ch_Frec_offset (Hz)
    start: '0'
    step: '0.0001'
    stop: '100'
    value: '0'
    widget: counter
  states: {}
- name: Ch_Jitter
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@0:0,2,1,1
    label: Ch_Jitter
    start: '-.001'
    step: '0.0001'
    stop: '.001'
    value: '0'
    widget: counter
  states: {}
- name: Ch_taps
  id: variable
  parameters:
    value: fftpack.ifftshift(fftpack.ifft([tap0, tap1, tap2, tap3, tap4, tap5, tap6, tap7]))
  states: {}
- name: Constelacion
  id: variable
  parameters:
    value: '[1.+0.j,    -1.+0.j ]'
  states: {state: disabled}
- name: Constelacion
  id: variable
  parameters:
    value: '[1.+0.j,   0.+1.j,   -1.+0.j,  0.-1.j ]'
  states: {}
- name: Fc
  id: variable
  parameters:
    value: 80e6
  states: {}
- name: M
  id: variable
  parameters:
    value: len(Constelacion)
  states: {}
- name: MiconstellationObject
  id: variable_constellation
  parameters:
    const_points: Constelacion
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: numpy.arange(M)
    type: calcdist
  states: {}
- name: NbpCode
  id: variable
  parameters:
    value: len(code1)+10.
  states: {}
- name: NbpS
  id: variable
  parameters:
    value: '8'
  states: {}
- name: NnivelesQ
  id: variable
  parameters:
    value: math.pow(2,NbpS)
  states: {}
- name: NodB
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@0:0,0,1,1
    label: Ch_No(dB)
    start: '-140.'
    step: '1.'
    stop: '0.'
    value: '-80'
    widget: counter
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rbi
  states: {}
- name: Rbi
  id: variable
  parameters:
    value: NbpS*samp_rate_audio
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/Bps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: Sps_o
  id: variable
  parameters:
    value: Sps
  states: {}
- name: SymbTune
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@2:0,1,1,1
    label: SymbTunning
    rangeType: int
    start: '0'
    step: '1'
    stop: '1000'
    value: '2'
    widget: counter
  states: {}
- name: TimingDelay
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@2:0,0,1,1
    label: Manual Timing
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: '0'
    widget: counter
  states: {state: disabled}
- name: Tmax_scope
  id: variable
  parameters:
    value: 64./Rs
  states: {}
- name: Vp
  id: variable
  parameters:
    value: '1.'
  states: {}
- name: W
  id: variable
  parameters:
    value: Rs/2
  states: {}
- name: code1
  id: variable
  parameters:
    value: '''010110011011101100010101011111101001001110001011010001101010001'''
  states: {}
- name: eq_gain
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: Sps*16
  states: {}
- name: payload
  id: variable
  parameters:
    value: '128'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: rrc_taps_rx
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(Sps), rolloff, ntaps*nfilts)
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '11000'
  states: {}
- name: tap0
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@1:0,0,1,1
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.25'
    widget: slider
  states: {}
- name: tap1
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@1:0,1,1,1
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.05'
    widget: slider
  states: {}
- name: tap2
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@1:0,2,1,1
    start: '0.25'
    step: '0.01'
    stop: '1'
    value: '1'
    widget: slider
  states: {}
- name: tap3
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@1:0,3,1,1
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
    widget: slider
  states: {}
- name: tap4
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@1:1,0,1,1
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.25'
    widget: slider
  states: {}
- name: tap5
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@1:1,1,1,1
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
    widget: slider
  states: {}
- name: tap6
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@1:1,2,1,1
    start: '0.25'
    step: '0.01'
    stop: '1'
    value: '1'
    widget: slider
  states: {}
- name: tap7
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@1:1,3,1,1
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
    widget: slider
  states: {}
- name: Instrumentos
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,2
    label0: Capa0.Canal y precanal
    label1: Capas.Pre-modulacion
    label2: Capa1. Modulacion
    label3: Capa2. CodificacionDeSimbolos
    num_tabs: '4'
  states: {}
- name: Pre_modulacion
  id: qtgui_tab_widget
  parameters:
    gui_hint: Instrumentos@1:1,0,1,1
    label0: Capa8.Mensaje continuo
    label1: Capa7.Cuantificacion
    label2: Capa6.PCM
    label3: Capa5.Otrastecnicas
    label4: Capa4.CodificacionBinaria
    label5: Capa3.M-PAM
    num_tabs: '6'
  states: {}
- name: Tx
  id: virtual_sink
  parameters:
    stream_id: T0
  states: {}
- name: Tx_0
  id: virtual_sink
  parameters:
    stream_id: T2
  states: {}
- name: Tx_1
  id: virtual_sink
  parameters:
    stream_id: T3
  states: {state: disabled}
- name: Tx_1_0
  id: virtual_sink
  parameters:
    stream_id: T8
  states: {state: disabled}
- name: Tx_1_0_0
  id: virtual_sink
  parameters:
    stream_id: T7
  states: {state: disabled}
- name: Tx_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R8
  states: {state: disabled}
- name: Tx_1_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R7
  states: {state: disabled}
- name: Tx_1_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: R6
  states: {state: disabled}
- name: Tx_1_0_0_2
  id: virtual_sink
  parameters:
    stream_id: T6
  states: {state: disabled}
- name: Tx_3
  id: virtual_sink
  parameters:
    stream_id: T1
  states: {}
- name: Tx_3_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R1
  states: {}
- name: Tx_3_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R1.1
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: M
    min: '0'
    num_samps: '1000000'
    repeat: 'True'
    type: byte
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_audio
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_audio
  states: {state: disabled}
- name: b_Eye_Diagram_simple_c_0
  id: b_Eye_Diagram_simple_c
  parameters:
    AlphaLineas: '0.5'
    Delay_i: '0'
    GrosorLineas: '20'
    Kint: '1'
    N_eyes: '2'
    Samprate1: samp_rate
    Sps1: Sps
    Title: '"salida del canal"'
    Ymax: '2'
    Ymin: '-2'
    gui_hint: canal@1:1,0,1,1
  states: {}
- name: b_Eye_Diagram_simple_c_0_0
  id: b_Eye_Diagram_simple_c
  parameters:
    AlphaLineas: '0.5'
    Delay_i: '0'
    GrosorLineas: '20'
    Kint: '1'
    N_eyes: '2'
    Samprate1: samp_rate
    Sps1: Sps
    Title: '"Entrada del ecualizador"'
    Ymax: '2'
    Ymin: '-2'
    gui_hint: canal@2:1,0,1,1
  states: {}
- name: b_M_PAM_bb_0
  id: b_M_PAM_bb
  parameters:
    M: M
  states: {state: disabled}
- name: b_RRaised_cosine_cc_0
  id: b_RRaised_cosine_cc
  parameters:
    Ganancia: '1.'
    Interpolation: Sps
    ntaps: ntaps*Sps
    rolloff: rolloff
    sps: Sps
  states: {}
- name: b_de_M_PAM_bb_0
  id: b_de_M_PAM_bb
  parameters:
    M: M
  states: {state: disabled}
- name: b_de_M_PAM_bb_0_0
  id: b_de_M_PAM_bb
  parameters:
    M: M
  states: {state: disabled}
- name: b_quantizer_fb_0
  id: b_quantizer_fb
  parameters:
    NivelesQ: NnivelesQ
    Vmax: Vp
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: SymbTune*Bps
    type: byte
  states: {state: disabled}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: Ch_Delay*Sps
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: SymbTune*Bps
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Vp/(NnivelesQ/2)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Vp/(NnivelesQ/2)
    type: float
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: NbpS
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: NbpS
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_audio
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: NbpS
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/comdig1/Dropbox/EnUbuntuFull/ClaseComDig/LibroAplicativos/Capitilo 2/Lab2.4/bush-clinton_debate_waffle.wav
    repeat: 'True'
  states: {state: disabled}
- name: canal
  id: qtgui_tab_widget
  parameters:
    gui_hint: Instrumentos@0:1,0,1,1
    label0: H(f) y Espectro
    label1: Diagrama de ojo canal
    label2: Diagrama de ojo ecualizador
    label3: Constelacion
    label4: La Ecualizacion
    num_tabs: '5'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: Ch_Jitter+1.
    freq_offset: Ch_Frec_offset
    noise_voltage: math.pow(10.,(NodB)/20.)
    seed: '13'
    taps: Ch_taps
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,1,1,1
    label0: Ch_Offsets
    label1: Ch_Taps
    label2: Tuning
    num_tabs: '3'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: Constelacion
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: M
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: M
  states: {state: disabled}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: M
  states: {state: disabled}
- name: digital_lms_dd_equalizer_cc_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: MiconstellationObject
    mu: eq_gain
    num_taps: '11'
    sps: Sps_o
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*math.pi/100.0
    max_dev: '1.5'
    osps: Sps_o
    sps: Sps
    taps: rrc_taps_rx
    type: ccf
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*math.pi/100.0
    max_dev: '1.5'
    osps: '1'
    sps: Sps
    taps: rrc_taps_rx
    type: ccf
  states: {}
- name: e1_0_0_0_1_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: T1
  states: {}
- name: e1_0_0_0_1_0_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: R1.1
  states: {}
- name: e1_0_0_0_1_0_0_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: R0
  states: {}
- name: e1_0_0_0_1_0_0_0_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: R0.1
  states: {}
- name: e1_0_0_0_1_0_0_0_0_1_0_1
  id: virtual_source
  parameters:
    stream_id: R1
  states: {}
- name: e1_0_0_0_1_0_0_0_0_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: R0.1
  states: {}
- name: e1_0_0_0_1_0_0_0_0_1_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: R1
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_1_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_1_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_scipy
  id: import
  parameters:
    imports: from scipy import fftpack
  states: {}
- name: note_0
  id: note
  parameters:
    note: CAPA8 MENSAJE
  states: {state: disabled}
- name: note_0_0
  id: note
  parameters:
    note: CAPA7 CUANTIFICACION
  states: {state: disabled}
- name: note_0_0_0
  id: note
  parameters:
    note: CAPA3 M-PAM
  states: {state: disabled}
- name: note_0_0_0_0
  id: note
  parameters:
    note: CAPA2 DIF.
  states: {state: disabled}
- name: note_0_0_0_0_0
  id: note
  parameters:
    note: CAPA1 MODULACION
  states: {}
- name: note_0_0_0_0_0_0
  id: note
  parameters:
    note: CAPA0.1 PRECANAL
  states: {}
- name: note_0_0_0_1
  id: note
  parameters:
    note: CAPA6-PCM
  states: {state: disabled}
- name: note_0_0_1
  id: note
  parameters:
    note: CAPA0 CANAL
  states: {}
- name: note_0_0_1_2
  id: note
  parameters:
    note: INSTRUMENTACION
  states: {}
- name: qtgui_const_sink_x_0_1_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: canal@3:1,0,1,1
    label1: Entrada de canal
    label2: Salida del Canal
    name: ''
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: canal@3:1,1,1,1
    label1: Salida del Ecualizador
    name: ''
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1_1_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: canal@4:0,0,1,1
    label1: Equalizer input
    name: ''
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1_1_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: canal@4:0,1,1,1
    label1: Equalizer output
    name: ''
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: Rs
    fc: '0'
    fftsize: '1024'
    gui_hint: canal@0:1,0,1,1
    label1: Entrada del canal
    label2: salida del canal
    name: ''
    nconnections: '2'
    showports: 'True'
    type: complex
    width1: '2'
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: Rs*Sps_o
    fc: '0'
    fftsize: '1024'
    gui_hint: canal@4:1,0,1,1
    label: H(f)
    label1: Equalizer input
    name: ''
    showports: 'True'
    type: complex
    width1: '2'
  states: {}
- name: qtgui_freq_sink_x_0_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: Rs
    fc: '0'
    fftsize: '1024'
    gui_hint: canal@4:1,1,1,1
    label: H(f)
    label1: Equalizer output
    name: ''
    showports: 'True'
    type: complex
    width1: '2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: Rs
    fc: '0'
    fftsize: '1024'
    gui_hint: canal@0:1,1,1,1
    int_max: '-30'
    int_min: '-50'
    showports: 'True'
    type: complex
  states: {}
- name: s1_1_0
  id: virtual_sink
  parameters:
    stream_id: R0
  states: {}
- name: s1_1_0_0
  id: virtual_sink
  parameters:
    stream_id: R2
  states: {}
- name: s1_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R3
  states: {state: disabled}
- name: s1_1_0_1
  id: virtual_sink
  parameters:
    stream_id: R0.1
  states: {}

connections:
- [analog_agc2_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_agc2_xx_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [analog_agc2_xx_0, '0', s1_1_0, '0']
- [analog_random_source_x_0, '0', Tx_0, '0']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [b_M_PAM_bb_0, '0', Tx_1, '0']
- [b_M_PAM_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [b_RRaised_cosine_cc_0, '0', Tx, '0']
- [b_RRaised_cosine_cc_0, '0', channels_channel_model_0, '0']
- [b_de_M_PAM_bb_0, '0', Tx_1_0_0_1_0, '0']
- [b_de_M_PAM_bb_0, '0', blocks_delay_0, '0']
- [b_de_M_PAM_bb_0_0, '0', blocks_delay_0_1, '0']
- [b_quantizer_fb_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_delay_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_delay_0_0, '0', analog_agc2_xx_0, '0']
- [blocks_delay_0_1, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', Tx_1_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', audio_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', Tx_1_0_0_1, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_throttle_0, '0', Tx_1_0_0, '0']
- [blocks_throttle_0, '0', blocks_unpack_k_bits_bb_0_1, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', Tx_1_0_0_2, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', b_M_PAM_bb_0, '0']
- [blocks_wavfile_source_0, '0', Tx_1_0, '0']
- [blocks_wavfile_source_0, '0', b_quantizer_fb_0, '0']
- [channels_channel_model_0, '0', blocks_delay_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', Tx_3, '0']
- [digital_chunks_to_symbols_xx_0, '0', b_RRaised_cosine_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_null_sink_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0, '0', s1_1_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_null_sink_1_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_diff_decoder_bb_0, '0', b_de_M_PAM_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', s1_1_0_0_0, '0']
- [digital_diff_decoder_bb_0_0, '0', b_de_M_PAM_bb_0_0, '0']
- [digital_diff_encoder_bb_0, '0', Tx_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', Tx_3_0_0_0_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_lms_dd_equalizer_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', s1_1_0_1, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', Tx_3_0_0_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [e1_0_0_0_1_0_0_0_0_1, '0', qtgui_const_sink_x_0_1_1, '0']
- [e1_0_0_0_1_0_0_0_0_1, '0', qtgui_freq_sink_x_0_1, '0']
- [e1_0_0_0_1_0_0_0_0_1_0, '0', qtgui_const_sink_x_0_1_1, '1']
- [e1_0_0_0_1_0_0_0_0_1_0, '0', qtgui_freq_sink_x_0_1, '1']
- [e1_0_0_0_1_0_0_0_0_1_0, '0', qtgui_waterfall_sink_x_0, '0']
- [e1_0_0_0_1_0_0_0_0_1_0_0, '0', b_Eye_Diagram_simple_c_0, '0']
- [e1_0_0_0_1_0_0_0_0_1_0_0_0, '0', b_Eye_Diagram_simple_c_0_0, '0']
- [e1_0_0_0_1_0_0_0_0_1_0_1, '0', qtgui_const_sink_x_0_1_1_0, '0']
- [e1_0_0_0_1_0_0_0_0_1_0_1_0, '0', qtgui_const_sink_x_0_1_1_0_0, '0']
- [e1_0_0_0_1_0_0_0_0_1_0_1_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [e1_0_0_0_1_0_0_0_0_1_0_1_0_0, '0', qtgui_const_sink_x_0_1_1_0_0_0, '0']
- [e1_0_0_0_1_0_0_0_0_1_0_1_0_0, '0', qtgui_freq_sink_x_0_1_0_0, '0']

metadata:
  file_format: 1
