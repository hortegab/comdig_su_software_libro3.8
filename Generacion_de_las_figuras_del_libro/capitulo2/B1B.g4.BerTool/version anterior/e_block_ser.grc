<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>e_block_ser</value></param>
<param><key>author</key><value>Mancipe Andres, Padilla Astrid, Castillo Jeyson </value></param>
<param><key>category</key><value>[E3TRadio]</value></param>
<param><key>description</key><value>Bloque Para el calculo de los valores de BER/SER para cualquier tipo de modulación. EL bloque tiene como parámetros de entrada N: como numero de puntos disponibles dentro del rango Eb/N0; SNRmin: valor de la relación señal a ruido minima; SNRmax: relacion señal a ruido maxima. Las señales de entrada son in Tx: son los bits transmitidos; in Rx : son los bits recibidos; in es la entrada de la envolvente compleja de la señal modulada. Las salidas del bloque son out env: es la salida de la envolvente compleja con la adicion de ruido AWGN; out ser: son los valores de BER/SER disponibles</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>e_block_ser</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>B</value></param>
<param><key>label</key><value>B</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>EbN0max</value></param>
<param><key>label</key><value>EbN0max</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>EbN0min</value></param>
<param><key>label</key><value>EbN0min</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N</value></param>
<param><key>label</key><value>N</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Rb</value></param>
<param><key>label</key><value>Rb</value></param>
<param><key>value</key><value>125</value></param>
</block>
<block>
<key>SERcurvas2_e_BER_tool</key>
<param><key>id</key><value>SERcurvas2_e_BER_tool_0</value></param>
<param><key>N</key><value>N</value></param>
</block>
<block>
<key>SERcurvas2_e_canal_BER</key>
<param><key>id</key><value>SERcurvas2_e_canal_BER_0</value></param>
<param><key>B</key><value>B</value></param>
<param><key>EbN0max</key><value>EbN0max</value></param>
<param><key>EbN0min</key><value>EbN0min</value></param>
<param><key>N</key><value>N</value></param>
<param><key>Rb</key><value>Rb</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out_env</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out_ser</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0</value></param>
<param><key>label</key><value>in_Tx</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0_0</value></param>
<param><key>label</key><value>in_Rx</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>SERcurvas2_e_BER_tool_0</source_block_id><sink_block_id>pad_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SERcurvas2_e_canal_BER_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SERcurvas2_e_canal_BER_0</source_block_id><sink_block_id>SERcurvas2_e_BER_tool_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>SERcurvas2_e_canal_BER_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0</source_block_id><sink_block_id>SERcurvas2_e_BER_tool_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0_0</source_block_id><sink_block_id>SERcurvas2_e_BER_tool_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
