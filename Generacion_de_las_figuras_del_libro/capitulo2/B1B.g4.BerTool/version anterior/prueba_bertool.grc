<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ser_simulation</value></param>
<param><key>author</key><value>Homero Ortega Boada</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>dale un valor a Eb/No, corre el flujograma y obten la SER. Puedes sacar tantos valores como para construir una curva de SER</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
<param><key>title</key><value>SER Simulation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bps</value></param>
<param><key>value</key><value>int(math.log(M,2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EbN0</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EbN0max</value></param>
<param><key>value</key><value>20.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EbN0min</value></param>
<param><key>value</key><value>0.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>len(const)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>MaxCount</value></param>
<param><key>value</key><value>int(1e7)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>MaxErrors</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>MiconstellationObject</value></param>
<param><key>const_points</key><value>const</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value></value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_snr</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>value</key><value>Rs*Bps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>samp_rate/Sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>digital.qam_constellation(16).points()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>digital.constellation_bpsk().points()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const</value></param>
<param><key>value</key><value>[(1.+0.j),(0.+1.j),(-1.+0.j),(0.-1.j)]</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x</value></param>
<param><key>max</key><value>M</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>10000000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>N_snr</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>const</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>MiconstellationObject</value></param>
</block>
<block>
<key>e_block_ser</key>
<param><key>id</key><value>e_block_ser_0</value></param>
<param><key>B</key><value>samp_rate/2</value></param>
<param><key>EbN0max</key><value>EbN0max</value></param>
<param><key>EbN0min</key><value>EbN0min</value></param>
<param><key>N</key><value>N_snr</value></param>
<param><key>Rb</key><value>Rb</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Modulación BPSK</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>Modulación 16QAM</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>note</key><value>Modulación 4PSK</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>alpha1</key><value>0.6</value></param>
<param><key>label1</key><value>Rx</value></param>
<param><key>label2</key><value>Tx</value></param>
<param><key>name</key><value>"Constelacion"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>N_snr</value></param>
<param><key>x_axis_label</key><value>"EbN0[dB]"</value></param>
<param><key>x_start</key><value>EbN0min</value></param>
<param><key>x_step</key><value>(EbN0max-EbN0min)/float(N_snr)</value></param>
<param><key>x_units</key><value>"dB"</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-2</value></param>
<param><key>y_axis_label</key><value>"log10(Pe)"</value></param>
<param><key>y_units</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs0</value></param>
<param><key>stream_id</key><value>TX1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs1</value></param>
<param><key>stream_id</key><value>RX1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>RX2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs6_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>TX2</value></param>
</block>
<connection><source_block_id>analog_random_source_x</source_block_id><sink_block_id>blocks_throttle</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle</source_block_id><sink_block_id>digital_chunks_to_symbols_xx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle</source_block_id><sink_block_id>e_block_ser_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle</source_block_id><sink_block_id>vs0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx</source_block_id><sink_block_id>e_block_ser_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>e_block_ser_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>vs1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_block_ser_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_block_ser_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vs6</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vs6_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
