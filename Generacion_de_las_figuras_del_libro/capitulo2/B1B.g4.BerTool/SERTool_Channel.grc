<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>SERTool_Channel</value></param>
<param><key>author</key><value>Mancipe Andres, Padilla Astrid, Castillo Jeyson </value></param>
<param><key>category</key><value>[E3TRadio]</value></param>
<param><key>description</key><value>Bloque Para el calculo de los valores de SER para cualquier tipo de modulación. EL bloque tiene como parámetros de entrada N: como numero de puntos disponibles dentro del rango Eb/N0; SNRmin: valor de la relación señal a ruido minima; SNRmax: relacion señal a ruido maxima. Las señales de entrada son in Tx: son los bits transmitidos; in Rx : son los bits recibidos; in es la entrada de la envolvente compleja de la señal modulada. Las salidas del bloque son out env: es la salida de la envolvente compleja con la adicion de ruido AWGN; out ser: son los valores de BER/SER disponibles</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
<param><key>title</key><value>SERTool_Channel</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>B</value></param>
<param><key>label</key><value>B</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>EsN0max</value></param>
<param><key>label</key><value>EsN0max</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>EsN0min</value></param>
<param><key>label</key><value>EsN0min</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_snr</value></param>
<param><key>label</key><value>N_snr</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Rs</value></param>
<param><key>label</key><value>Rs</value></param>
<param><key>value</key><value>125</value></param>
</block>
<block>
<key>SERcurvas2_e_BER_tool</key>
<param><key>id</key><value>SERcurvas2_e_BER_tool_0</value></param>
<param><key>N</key><value>N_snr</value></param>
</block>
<block>
<key>SERcurvas2_e_canal_BER</key>
<param><key>id</key><value>SERcurvas2_e_canal_BER_0</value></param>
<param><key>B</key><value>B</value></param>
<param><key>EsN0max</key><value>EsN0max</value></param>
<param><key>EsN0min</key><value>EsN0min</value></param>
<param><key>N</key><value>N_snr</value></param>
<param><key>Rs</key><value>Rs</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>N_snr</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out_env</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0</value></param>
<param><key>label</key><value>in_Tx</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0_0</value></param>
<param><key>label</key><value>in_Rx</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>name</key><value>"Curva de SER"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>N_snr</value></param>
<param><key>x_axis_label</key><value>"Es/N0 [dB]"</value></param>
<param><key>x_start</key><value>EsN0min</value></param>
<param><key>x_step</key><value>(EsN0max-EsN0min)/float(N_snr)</value></param>
<param><key>x_units</key><value>"dB"</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-2</value></param>
<param><key>y_axis_label</key><value>"10logPe"</value></param>
</block>
<connection><source_block_id>SERcurvas2_e_BER_tool_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SERcurvas2_e_canal_BER_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SERcurvas2_e_canal_BER_0</source_block_id><sink_block_id>SERcurvas2_e_BER_tool_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>SERcurvas2_e_canal_BER_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0</source_block_id><sink_block_id>SERcurvas2_e_BER_tool_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0_0</source_block_id><sink_block_id>SERcurvas2_e_BER_tool_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
