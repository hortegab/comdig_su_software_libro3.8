options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: Lab_total
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: Ensayos
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: Fc
  id: variable
  parameters:
    value: 80e6
  states: {}
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: NbpS
  id: variable
  parameters:
    value: '8'
  states: {}
- name: NnivelesQ
  id: variable
  parameters:
    value: int(math.pow(2,NbpS))
  states: {}
- name: Rb
  id: variable
  parameters:
    value: NbpS*samp_rate_audio
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Tmax_scope
  id: variable
  parameters:
    value: 16./samp_rate_audio
  states: {}
- name: Vp
  id: variable
  parameters:
    value: '0.6'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: menu@0:0,0,2,2
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '11000'
  states: {}
- name: E3TRadio_Zero_Order_Hold_0
  id: E3TRadio_Zero_Order_Hold
  parameters:
    k: NbpS
  states: {}
- name: Rx_1_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R7
  states: {}
- name: Tx_1_0
  id: virtual_sink
  parameters:
    stream_id: T8
  states: {}
- name: Tx_1_0_0
  id: virtual_sink
  parameters:
    stream_id: T7
  states: {}
- name: Tx_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R8
  states: {}
- name: Tx_1_0_0_1
  id: virtual_sink
  parameters:
    stream_id: T6
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_audio
  states: {state: disabled}
- name: b_quantizer_fb_0
  id: b_quantizer_fb
  parameters:
    NivelesQ: NnivelesQ
    Vmax: Vp
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2./NnivelesQ
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Vp/(NnivelesQ/2)
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: NbpS
  states: {}
- name: blocks_unpack_k_bits_bb_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: NbpS
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/MisGits/comdig_su_software_libro3.8/Generacion_de_las_figuras_del_libro/bush-clinton_debate_waffle.wav
    repeat: 'True'
  states: {}
- name: e1_0_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: T6
  states: {}
- name: e1_0_0_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: T7
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_1_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_1_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: menu
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    num_tabs: '1'
  states: {}
- name: note_0
  id: note
  parameters:
    note: CAPA8 MENSAJE
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: CAPA7 CUANTIFICACION
  states: {}
- name: note_0_0_1_2
  id: note
  parameters:
    note: INSTRUMENTACION
  states: {}
- name: note_0_0_2
  id: note
  parameters:
    note: CAPA6 PCM
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@0:3,0
    label1: '"PCM "'
    label2: Cuantificada
    marker1: '0'
    nconnections: '2'
    size: '64'
    srate: Rb
    type: float
    width1: '4'
    width2: '4'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [E3TRadio_Zero_Order_Hold_0, '0', blocks_multiply_const_vxx_0, '0']
- [b_quantizer_fb_0, '0', Tx_1_0_0, '0']
- [b_quantizer_fb_0, '0', blocks_unpack_k_bits_bb_0_1, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', E3TRadio_Zero_Order_Hold_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', Tx_1_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_null_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', Rx_1_0_0_1, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', Tx_1_0_0_1, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_wavfile_source_0, '0', Tx_1_0, '0']
- [blocks_wavfile_source_0, '0', b_quantizer_fb_0, '0']
- [e1_0_0_0_0_0_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [e1_0_0_0_0_0_0_0_0, '0', blocks_char_to_float_0_0_0_0, '0']

metadata:
  file_format: 1
