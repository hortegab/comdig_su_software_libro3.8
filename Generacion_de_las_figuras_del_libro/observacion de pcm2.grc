<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Lab_total</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ensayos</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fc</value></param>
<param><key>value</key><value>80e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NbpS</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NnivelesQ</value></param>
<param><key>value</key><value>math.pow(2,NbpS)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>value</key><value>NbpS*samp_rate_audio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>Rb</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Tmax_scope</value></param>
<param><key>value</key><value>16./samp_rate_audio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vp</value></param>
<param><key>value</key><value>0.6</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>menu@0:0,0,2,2</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_audio</value></param>
<param><key>value</key><value>11000</value></param>
</block>
<block>
<key>E3TRadio_Zero_Order_Hold</key>
<param><key>id</key><value>E3TRadio_Zero_Order_Hold_0</value></param>
<param><key>k</key><value>NbpS</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Rx_1_0_0_1</value></param>
<param><key>stream_id</key><value>R7</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0</value></param>
<param><key>stream_id</key><value>T8</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0</value></param>
<param><key>stream_id</key><value>T7</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_0</value></param>
<param><key>stream_id</key><value>R8</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_1</value></param>
<param><key>stream_id</key><value>T6</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
</block>
<block>
<key>b_quantizer_fb</key>
<param><key>id</key><value>b_quantizer_fb_0</value></param>
<param><key>NivelesQ</key><value>NnivelesQ</value></param>
<param><key>Vmax</key><value>Vp</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>2./NnivelesQ</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>Vp/(NnivelesQ/2)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>NbpS</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_1</value></param>
<param><key>k</key><value>NbpS</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/comdiguis2/MisGitHubs/Libro_su_software/capitulo4/bush-clinton_debate_waffle.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>T6</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>T7</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>menu</value></param>
<param><key>label0</key><value>Tab 0</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>CAPA8 MENSAJE</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>CAPA7 CUANTIFICACION</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_1_2</value></param>
<param><key>note</key><value>INSTRUMENTACION</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_2</value></param>
<param><key>note</key><value>CAPA6 PCM</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>menu@0:3,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"PCM "</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>width1</key><value>4</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Cuantificada</value></param>
<param><key>width2</key><value>4</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>64</value></param>
<param><key>srate</key><value>Rb</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<connection><source_block_id>E3TRadio_Zero_Order_Hold_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_quantizer_fb_0</source_block_id><sink_block_id>Tx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_quantizer_fb_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0_0</source_block_id><sink_block_id>E3TRadio_Zero_Order_Hold_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>Tx_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>Rx_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_1</source_block_id><sink_block_id>Tx_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_1</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>Tx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>b_quantizer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
