options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: B
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: Fc
  id: variable
  parameters:
    value: '60000'
  states: {}
- name: Fmax
  id: variable
  parameters:
    value: Fc+B
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4*Fmax
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: b_PSD_0
  id: b_PSD
  parameters:
    Ensayos: '1000000'
    N: '1024'
    Titulo: '''espectro'''
    Ymax: '1.'
    gui_hint: 3,0,1,1
    samp_rate_audio: samp_rate
  states: {state: disabled}
- name: b_PSD_0_0
  id: b_PSD
  parameters:
    Ensayos: '1000000'
    N: '1024'
    Titulo: '''espectro'''
    Ymax: '1.'
    gui_hint: 3,1,1,1
    samp_rate_audio: samp_rate
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: Fc+B/2
    low_cutoff_freq: Fc-B/2
    samp_rate: samp_rate
    type: fir_filter_fff
    width: (B/2)/16
    win: window.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: Fc
    fftsize: '1024'
    gui_hint: 1,0,1,1
    label1: '.'
    name: '"PSD. Ruido blanco"'
    showports: 'True'
    type: float
    width1: '2'
    ymax: '-50'
    ymin: '-200'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: Fc
    fftsize: '1024'
    gui_hint: 2,0,1,1
    label1: '.'
    name: '"PSD. Ruido Blanco de Banda Angosta"'
    showports: 'True'
    type: float
    width1: '2'
    ymax: '-50'
    ymin: '-200'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1,1,1,1
    label1: '.'
    name: '"Ruido Blanco"'
    size: '1024'
    srate: samp_rate
    type: float
    width1: '2'
    ylabel: Amplitud
    ymax: '0.0003'
    ymin: '-0.0003'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,1,1,1
    label1: '.'
    name: '"Ruido Blanco de Banda Angosta"'
    size: '1024'
    srate: samp_rate
    type: float
    width1: '2'
    ylabel: Amplitud
    ymax: '0.0003'
    ymin: '-0.0003'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: a1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: a2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: a1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: a2
  states: {}

connections:
- [analog_noise_source_x_0_0, '0', band_pass_filter_0, '0']
- [analog_noise_source_x_0_0, '0', virtual_sink_0, '0']
- [band_pass_filter_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
