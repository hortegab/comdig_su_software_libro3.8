options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: Lab_total
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: BpS
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Constelacion
  id: variable
  parameters:
    value: digital.constellation_qpsk().points()
  states: {}
- name: Ensayos
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: Fc
  id: variable
  parameters:
    value: 80e6
  states: {}
- name: M
  id: variable
  parameters:
    value: len(Constelacion)
  states: {}
- name: MiconstellationObject
  id: variable_constellation
  parameters:
    const_points: Constelacion
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: numpy.arange(M)
    type: calcdist
  states: {}
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: NbpS
  id: variable
  parameters:
    value: '8'
  states: {}
- name: NnivelesQ
  id: variable
  parameters:
    value: math.pow(2,NbpS)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: NbpS*samp_rate_audio
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/BpS
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: Tmax_scope
  id: variable
  parameters:
    value: 16./samp_rate_audio
  states: {}
- name: Vp
  id: variable
  parameters:
    value: '0.6'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: menu@0:0,0,1,2
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '11000'
  states: {}
- name: E3TRadio_Zero_Order_Hold_0
  id: E3TRadio_Zero_Order_Hold
  parameters:
    k: Sps
  states: {}
- name: E3TRadio_Zero_Order_Hold_0_0
  id: E3TRadio_Zero_Order_Hold
  parameters:
    k: Sps
  states: {}
- name: E3TRadio_Zero_Order_Hold_0_0_0
  id: E3TRadio_Zero_Order_Hold
  parameters:
    k: BpS
  states: {}
- name: E3TRadio_unipolar_to_bipolar_ff_0
  id: E3TRadio_unipolar_to_bipolar_ff
  parameters:
    Amp: '1.'
  states: {state: disabled}
- name: E3TRadio_unipolar_to_bipolar_ff_0_1
  id: E3TRadio_unipolar_to_bipolar_ff
  parameters:
    Amp: '1.'
  states: {state: disabled}
- name: Rx_1_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R7
  states: {state: disabled}
- name: Tx_1_0
  id: virtual_sink
  parameters:
    stream_id: T8
  states: {state: disabled}
- name: Tx_1_0_0
  id: virtual_sink
  parameters:
    stream_id: T7
  states: {state: disabled}
- name: Tx_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R8
  states: {state: disabled}
- name: Tx_1_0_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: R6
  states: {state: disabled}
- name: Tx_1_0_0_2_0
  id: virtual_sink
  parameters:
    stream_id: T6
  states: {state: disabled}
- name: Tx_1_0_0_2_1
  id: virtual_sink
  parameters:
    stream_id: T5
  states: {state: disabled}
- name: Tx_1_0_0_2_1_0
  id: virtual_sink
  parameters:
    stream_id: T4
  states: {}
- name: Tx_1_0_0_2_1_1
  id: virtual_sink
  parameters:
    stream_id: T5
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_audio
  states: {state: disabled}
- name: b_bipolar_to_unipolar_ff_0
  id: b_bipolar_to_unipolar_ff
  parameters: {}
  states: {state: disabled}
- name: b_bipolar_to_unipolar_ff_1
  id: b_bipolar_to_unipolar_ff
  parameters: {}
  states: {state: disabled}
- name: b_quantizer_fb_0
  id: b_quantizer_fb
  parameters:
    NivelesQ: NnivelesQ
    Vmax: Vp
  states: {state: disabled}
- name: b_scrambling_ff_0
  id: b_scrambling_ff
  parameters:
    retardo: '0'
    semilla: '42'
  states: {state: disabled}
- name: b_scrambling_ff_0_0
  id: b_scrambling_ff
  parameters:
    retardo: '0'
    semilla: '42'
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_2_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_char_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Vp/(NnivelesQ/2)
    type: float
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: NbpS
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: NbpS
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: BpS
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: NbpS
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: NbpS
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_1_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: NbpS
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: BpS
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (6,55)
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/comdiguis2/MisGitHubs/Libro_su_software/capitulo4/bush-clinton_debate_waffle.wav
    repeat: 'True'
  states: {state: disabled}
- name: e1_0_0_0_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: T4
  states: {}
- name: e1_0_0_0_0_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: T5
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_1_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_1_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: menu
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    num_tabs: '1'
  states: {}
- name: note_0
  id: note
  parameters:
    note: CAPA8 MENSAJE
  states: {state: disabled}
- name: note_0_0
  id: note
  parameters:
    note: CAPA7 CUANTIFICACION
  states: {state: disabled}
- name: note_0_0_1_2
  id: note
  parameters:
    note: INSTRUMENTACION
  states: {}
- name: note_0_0_2
  id: note
  parameters:
    note: CAPA6 PCM
  states: {}
- name: note_0_0_2_0
  id: note
  parameters:
    note: CAPA5 Energy dispersal
  states: {}
- name: note_0_0_2_0_0
  id: note
  parameters:
    note: CAPA4 M-PAM
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: Rb*Sps
    fc: '0'
    fftsize: '1024'
    gui_hint: menu@0:1,0,1,1
    label1: Binaria
    label2: M-PAM
    nconnections: '2'
    showports: 'True'
    type: float
    width1: '4'
    width2: '4'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@0:3,0
    label1: '"M-PAM"'
    marker1: '0'
    size: '16'
    srate: Rs
    type: float
    width1: '4'
    ymax: M
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@0:2,0
    label1: Binaria
    marker1: '0'
    size: 16*BpS
    srate: Rb
    type: float
    width1: '4'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@0:4,0
    label1: Binaria
    size: 16*BpS*Sps
    srate: Rb*Sps
    type: float
    width1: '4'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@0:5,0
    label1: '"M-PAM"'
    size: 16*Sps
    srate: Rs*Sps
    type: float
    width1: '4'
    ymax: M
    ymin: '-1.5'
  states: {}

connections:
- [E3TRadio_Zero_Order_Hold_0, '0', qtgui_freq_sink_x_0, '0']
- [E3TRadio_Zero_Order_Hold_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [E3TRadio_Zero_Order_Hold_0_0, '0', E3TRadio_Zero_Order_Hold_0_0_0, '0']
- [E3TRadio_Zero_Order_Hold_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [E3TRadio_Zero_Order_Hold_0_0_0, '0', qtgui_freq_sink_x_0, '1']
- [E3TRadio_unipolar_to_bipolar_ff_0, '0', b_scrambling_ff_0, '0']
- [E3TRadio_unipolar_to_bipolar_ff_0_1, '0', b_scrambling_ff_0_0, '0']
- [b_bipolar_to_unipolar_ff_0, '0', blocks_float_to_char_0, '0']
- [b_bipolar_to_unipolar_ff_1, '0', blocks_float_to_char_1, '0']
- [b_quantizer_fb_0, '0', Tx_1_0_0, '0']
- [b_quantizer_fb_0, '0', blocks_unpack_k_bits_bb_0_1, '0']
- [b_scrambling_ff_0, '0', Tx_1_0_0_2_1, '0']
- [b_scrambling_ff_0, '0', b_bipolar_to_unipolar_ff_1, '0']
- [b_scrambling_ff_0_0, '0', b_bipolar_to_unipolar_ff_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_char_to_float_0_0, '0', E3TRadio_unipolar_to_bipolar_ff_0, '0']
- [blocks_char_to_float_1, '0', E3TRadio_unipolar_to_bipolar_ff_0_1, '0']
- [blocks_char_to_float_2, '0', E3TRadio_Zero_Order_Hold_0_0, '0']
- [blocks_char_to_float_2, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_2_0, '0', E3TRadio_Zero_Order_Hold_0, '0']
- [blocks_char_to_float_2_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_float_to_char_0, '0', Tx_1_0_0_1_0_0, '0']
- [blocks_float_to_char_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_float_to_char_1, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', Tx_1_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', Rx_1_0_0_1, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', Tx_1_0_0_2_1_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', Tx_1_0_0_2_0, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0_1_0, '0', blocks_char_to_float_1, '0']
- [blocks_unpack_k_bits_bb_0_1_1, '0', Tx_1_0_0_2_1_1, '0']
- [blocks_unpack_k_bits_bb_0_1_1, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_unpack_k_bits_bb_0_1_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpack_k_bits_bb_0_1_1, '0']
- [blocks_wavfile_source_0, '0', Tx_1_0, '0']
- [blocks_wavfile_source_0, '0', b_quantizer_fb_0, '0']
- [e1_0_0_0_0_0_0_0_1, '0', blocks_char_to_float_2, '0']
- [e1_0_0_0_0_0_0_0_1_0, '0', blocks_char_to_float_2_0, '0']

metadata:
  file_format: 1
