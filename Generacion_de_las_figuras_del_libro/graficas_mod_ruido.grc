options:
  parameters:
    author: Homero Ortega Boada
    category: Custom
    description: Sps2, Rs2, Rb2  sido introducido con el fin de obtener una PSD sin tantos lobulos. Lo que hicimos es un sistema con dos salidas a diferentes velocidades
    generate_options: qt_gui
    id: Lab_total
    output_language: python
    run: run_stop
    title: Lab_total
  states: {}

blocks:
- name: MiconstellationObject0
  id: variable_constellation
  parameters:
    const_points: const[0].points()
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: numpy.arange(len(const[0].points()))
    type: calcdist
  states: {}
- name: MiconstellationObject1
  id: variable_constellation
  parameters:
    const_points: const[1].points()
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: numpy.arange(len(const[1].points()))
    type: calcdist
  states: {}
- name: MiconstellationObject2
  id: variable_constellation
  parameters:
    const_points: const[2].points()
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: numpy.arange(len(const[2].points()))
    type: calcdist
  states: {}
- name: MiconstellationObject3
  id: variable_constellation
  parameters:
    const_points: const[3].points()
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: numpy.arange(len(const[3].points()))
    type: calcdist
  states: {}
- name: const
  id: variable
  parameters:
    value: (digital.constellation_bpsk(), digital.constellation_qpsk(), digital.constellation_8psk(), digital.qam.qam_constellation(16))
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: M_PAM_1
  id: virtual_sink
  parameters:
    stream_id: bpsk
  states: {}
- name: M_PAM_1_0
  id: virtual_sink
  parameters:
    stream_id: qpsk
  states: {}
- name: M_PAM_1_0_0
  id: virtual_sink
  parameters:
    stream_id: 8psk
  states: {}
- name: M_PAM_1_0_1
  id: virtual_sink
  parameters:
    stream_id: 16qam
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: b_symb_source_0
  id: b_symb_source
  parameters:
    Constelacion: MiconstellationObject0.points()
  states: {}
- name: b_symb_source_0_0
  id: b_symb_source
  parameters:
    Constelacion: MiconstellationObject1.points()
  states: {}
- name: b_symb_source_0_0_0
  id: b_symb_source
  parameters:
    Constelacion: MiconstellationObject2.points()
  states: {}
- name: b_symb_source_0_0_1
  id: b_symb_source
  parameters:
    Constelacion: MiconstellationObject3.points()
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from random import randint, uniform
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import  numpy
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import random
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: '"BPSK                                                                                         ."'
    size: '1024'
    type: complex
    width1: '6'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,1,1,1
    label1: '"QPSK                                                                                         ."'
    size: '1024'
    type: complex
    width1: '6'
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2,1,1,1
    label1: '"16QAM                                                                                         ."'
    size: '1024'
    type: complex
    width1: '6'
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2,0,1,1
    label1: '"8PSK                                                                                         ."'
    size: '1024'
    type: complex
    width1: '6'
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: bpsk
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: qpsk
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: 16qam
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: 8psk
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0_0_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0_0_1, '1']
- [b_symb_source_0, '0', blocks_add_xx_0, '0']
- [b_symb_source_0_0, '0', blocks_add_xx_0_0, '0']
- [b_symb_source_0_0_0, '0', blocks_add_xx_0_0_0, '0']
- [b_symb_source_0_0_1, '0', blocks_add_xx_0_0_1, '0']
- [blocks_add_xx_0, '0', M_PAM_1, '0']
- [blocks_add_xx_0_0, '0', M_PAM_1_0, '0']
- [blocks_add_xx_0_0_0, '0', M_PAM_1_0_0, '0']
- [blocks_add_xx_0_0_1, '0', M_PAM_1_0_1, '0']
- [virtual_source_0_0_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_0_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_0_0_0_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [virtual_source_0_0_0_1, '0', qtgui_const_sink_x_0_1, '0']

metadata:
  file_format: 1
