options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: Fs
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Fs2
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Fs/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: b_binary_bipolar_source_f_0
  id: b_binary_bipolar_source_f
  parameters:
    Am: '1'
    Spb: Sps
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: Fs
    fc: '0'
    fftsize: N
    gui_hint: 0,0,1,1
    label1: '.'
    showports: 'True'
    type: float
    width1: '2'
    ymax: '-20'
    ymin: '-90'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: Fs2
    fc: '0'
    fftsize: N
    gui_hint: 1,0,1,1
    label1: '.'
    name: '"Con Rational Resampler"'
    showports: 'True'
    type: float
    width1: '2'
    ymax: '-20'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,1,1
    label1: '.'
    size: '128'
    srate: Fs
    type: float
    width1: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    label1: '.'
    name: '"Con Rational Resampler"'
    size: int(128*Fs2/Fs)
    srate: Fs2
    type: float
    width1: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Fs
    interp: Fs2
    taps: ''
    type: fff
  states: {}

connections:
- [b_binary_bipolar_source_f_0, '0', qtgui_freq_sink_x_0, '0']
- [b_binary_bipolar_source_f_0, '0', qtgui_time_sink_x_0, '0']
- [b_binary_bipolar_source_f_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
