options:
  parameters:
    author: Homero Ortega Boada
    category: Custom
    description: Dale un valor a Es/No, corre el flujograma y obten la SER. Puedes sacar tantos valores como para construir una curva de SER
    generate_options: qt_gui
    id: ser_simulation
    output_language: python
    run: run_stop
    title: SER Simulation
  states: {}

blocks:
- name: EsN0max
  id: variable
  parameters:
    value: '25.'
  states: {}
- name: EsN0min
  id: variable
  parameters:
    value: '-5.'
  states: {}
- name: M0
  id: variable
  parameters:
    value: len(const0)
  states: {}
- name: M1
  id: variable
  parameters:
    value: len(const1)
  states: {}
- name: M2
  id: variable
  parameters:
    value: len(const2)
  states: {}
- name: M3
  id: variable
  parameters:
    value: len(const3)
  states: {}
- name: MaxCount
  id: variable
  parameters:
    value: int(1e7)
  states: {}
- name: MaxErrors
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: MiconstellationObject0
  id: variable_constellation
  parameters:
    const_points: const0
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: np.arange(M0)
    type: calcdist
  states: {}
- name: MiconstellationObject1
  id: variable_constellation
  parameters:
    const_points: const1
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: np.arange(M1)
    type: calcdist
  states: {}
- name: MiconstellationObject2
  id: variable_constellation
  parameters:
    const_points: const2
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: np.arange(M2)
    type: calcdist
  states: {}
- name: MiconstellationObject3
  id: variable_constellation
  parameters:
    const_points: const3
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: np.arange(M3)
    type: calcdist
  states: {}
- name: N_snr
  id: variable
  parameters:
    value: '128'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: const
  id: variable
  parameters:
    value: digital.constellation_bpsk().points()
  states: {state: disabled}
- name: const
  id: variable
  parameters:
    value: digital.qam_constellation(16).points()
  states: {state: disabled}
- name: const0
  id: variable
  parameters:
    value: digital.constellation_bpsk().points()
  states: {}
- name: const1
  id: variable
  parameters:
    value: digital.constellation_qpsk().points()
  states: {}
- name: const2
  id: variable
  parameters:
    value: digital.constellation_8psk().points()
  states: {}
- name: const3
  id: variable
  parameters:
    value: digital.qam_constellation(16).points()
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: analog_random_source_x
  id: analog_random_source_x
  parameters:
    max: M2
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: M3
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: M1
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: M0
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: b_BERTool_0
  id: b_BERTool
  parameters:
    EsN0max: EsN0max
    EsN0min: EsN0min
    N_snr: N_snr
    Rs: Rs
  states: {}
- name: b_BERTool_0_0
  id: b_BERTool
  parameters:
    EsN0max: EsN0max
    EsN0min: EsN0min
    N_snr: N_snr
    Rs: Rs
  states: {}
- name: b_BERTool_0_0_0
  id: b_BERTool
  parameters:
    EsN0max: EsN0max
    EsN0min: EsN0min
    N_snr: N_snr
    Rs: Rs
  states: {}
- name: b_BERTool_0_1
  id: b_BERTool
  parameters:
    EsN0max: EsN0max
    EsN0min: EsN0min
    N_snr: N_snr
    Rs: Rs
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const2
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const3
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const1
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const0
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject3
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject2
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject0
  states: {}
- name: digital_constellation_decoder_cb_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject1
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.6'
    gui_hint: 1,2,1,1
    label1: Rx
    label2: Tx
    name: '"Constelacion"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,1,1
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,1,1,1
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2,1,1,1
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '1'
    gui_hint: 2,0,1,1
    label1: '"BPSK"'
    label2: '"QPSK"'
    label3: 8PSK
    label4: '"16QAM"'
    name: '"Curva de BER"'
    nconnections: '4'
    showports: 'True'
    vlen: N_snr
    width1: '4'
    width2: '4'
    width3: '4'
    width4: '4'
    x_axis_label: '"Es/N0 [dB]"'
    x_start: EsN0min
    x_step: (EsN0max-EsN0min)/float(N_snr)
    x_units: '"dB"'
    y_axis_label: '"logPe"'
    ymax: '0'
    ymin: '-8'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: TX3
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: RX3
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: RX2
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: RX0
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: RX1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: TX2
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: TX0
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: TX1
  states: {}
- name: vs0
  id: virtual_sink
  parameters:
    stream_id: TX2
  states: {}
- name: vs0_0
  id: virtual_sink
  parameters:
    stream_id: TX3
  states: {}
- name: vs0_0_0
  id: virtual_sink
  parameters:
    stream_id: TX1
  states: {}
- name: vs0_1
  id: virtual_sink
  parameters:
    stream_id: TX0
  states: {}
- name: vs1
  id: virtual_sink
  parameters:
    stream_id: RX3
  states: {}
- name: vs1_0
  id: virtual_sink
  parameters:
    stream_id: RX2
  states: {}
- name: vs1_0_0
  id: virtual_sink
  parameters:
    stream_id: RX0
  states: {}
- name: vs1_1
  id: virtual_sink
  parameters:
    stream_id: RX1
  states: {}
- name: vs6
  id: virtual_source
  parameters:
    stream_id: RX2
  states: {state: disabled}
- name: vs6_0
  id: virtual_source
  parameters:
    stream_id: TX2
  states: {state: disabled}

connections:
- [analog_random_source_x, '0', digital_chunks_to_symbols_xx, '0']
- [analog_random_source_x, '0', vs0, '0']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [analog_random_source_x_0, '0', vs0_0, '0']
- [analog_random_source_x_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [analog_random_source_x_0_0, '0', vs0_0_0, '0']
- [analog_random_source_x_1, '0', digital_chunks_to_symbols_xx_1, '0']
- [analog_random_source_x_1, '0', vs0_1, '0']
- [b_BERTool_0, '0', digital_constellation_decoder_cb_0, '0']
- [b_BERTool_0, '1', qtgui_vector_sink_f_0, '3']
- [b_BERTool_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [b_BERTool_0_0, '1', qtgui_vector_sink_f_0, '2']
- [b_BERTool_0_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [b_BERTool_0_0_0, '1', qtgui_vector_sink_f_0, '0']
- [b_BERTool_0_1, '0', digital_constellation_decoder_cb_0_1, '0']
- [b_BERTool_0_1, '1', qtgui_vector_sink_f_0, '1']
- [blocks_null_source_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_null_source_0, '0', qtgui_const_sink_x_1_0, '0']
- [blocks_null_source_0, '0', qtgui_const_sink_x_1_0_0, '0']
- [digital_chunks_to_symbols_xx, '0', b_BERTool_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', b_BERTool_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', b_BERTool_0_1, '0']
- [digital_chunks_to_symbols_xx_1, '0', b_BERTool_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', vs1, '0']
- [digital_constellation_decoder_cb_0_0, '0', vs1_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', vs1_0_0, '0']
- [digital_constellation_decoder_cb_0_1, '0', vs1_1, '0']
- [virtual_source_0, '0', b_BERTool_0, '1']
- [virtual_source_0_0, '0', b_BERTool_0, '2']
- [virtual_source_0_0_0, '0', b_BERTool_0_0, '1']
- [virtual_source_0_0_0_0, '0', b_BERTool_0_0_0, '1']
- [virtual_source_0_0_1, '0', b_BERTool_0_1, '1']
- [virtual_source_0_1, '0', b_BERTool_0_0, '2']
- [virtual_source_0_1_0, '0', b_BERTool_0_0_0, '2']
- [virtual_source_0_2, '0', b_BERTool_0_1, '2']
- [vs6, '0', qtgui_const_sink_x_0, '0']
- [vs6_0, '0', qtgui_const_sink_x_0, '1']

metadata:
  file_format: 1
