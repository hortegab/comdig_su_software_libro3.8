options:
  parameters:
    author: Homero Ortega Boada
    category: Custom
    description: Dale un valor a Es/No, corre el flujograma y obten la SER. Puedes sacar tantos valores como para construir una curva de SER
    generate_options: qt_gui
    id: ser_simulation
    output_language: python
    run: run_stop
    title: SER Simulation
  states: {}

blocks:
- name: EsN0max
  id: variable
  parameters:
    value: '35'
  states: {}
- name: EsN0min
  id: variable
  parameters:
    value: '0'
  states: {}
- name: M0
  id: variable
  parameters:
    value: len(const0)
  states: {}
- name: MaxCount
  id: variable
  parameters:
    value: int(1e7)
  states: {}
- name: MaxErrors
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: MiconstellationObject0
  id: variable_constellation
  parameters:
    const_points: const0
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: mapa
    type: calcdist
  states: {}
- name: N_snr
  id: variable
  parameters:
    value: '32'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: const0
  id: variable
  parameters:
    value: digital.constellation_bpsk().points()
  states: {}
- name: mapa
  id: variable
  parameters:
    value: np.arange(M0)
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: M0
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: ([1]*N_snr)
    num_outputs: N_snr
    type: byte
  states: {}
- name: blocks_stream_demux_0_0
  id: blocks_stream_demux
  parameters:
    lengths: ([1]*N_snr)
    num_outputs: N_snr
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N_snr
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N_snr
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const0
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject0
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    EsN0max: EsN0max
    EsN0min: EsN0min
    N: N_snr
    Rs: Rs
    Sps: Sps
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import math
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
      Es un canal AWGN (Additive White Gaussian Noise, en banda base), con entrada vectorial. Recibe la envolvente compleja de una senal con modulacion digital. Entrega la misma senal recibida pero con ruido blanco gausiano aditivo con diferentes valores de potencia que corresponden a N diferentes valores de Es/No entre EsNOmin y EsN0max (valores dados en dB). Este bloque se diferencia de otros bloques tradicionales de canal AWGN en lo siguiente: Tiene internamente una funcion que mide la potencia promedio de la senal entrante Ps, de modo que puede calcular Es=Ps/Rs; de esa manera puede N valores de potencia Pn para el ruido Pn para lograr los N valores de la relacion Es/No. Con esto ha completado el primer ensayo para que otro sea el bloque que calcule la Curva de SER. Pero alli no para, sino que sigue realizando tantos ensayos como lo permita el tiempo de simulacion, para que el bloque que calcula la Curva de BER la pueda ir perfeccionando cada vez mas.

      Datos de configuracion del bloque:
      N: Es la longitud del vector y coincide con el numero de puntos discretos que va a tener la curva de BER. Tambien corresponde al numero de valores que tomará la relacion Es/No
      EsN0min: El minimo valor a tener en cuenta para Es/No
      EsN0max: El maximo valor a tener en cuenta para Es/No
      Rs: es la rata de simbolos.
      Sps: El numero de muestras por simbolo. Usualmente es 1, pero pueden darse excepciones. 
      Es: es la energia de un simbolo

      Algunas variables internas son:
      No: es la Densidad espectral del potencia del ruido blanco.
      SNR: es la relacion senal a ruido
      """


          def __init__(self, N=32, EsN0min=0, EsN0max=16,Sps=1,Rs=1):  # only default arguments here
              """ """
              gr.sync_block.__init__(
                  self,
                  name='e_SER_Channel',   # will show up in GRC
                  in_sig=[(np.complex64,N)],
                  out_sig=[(np.complex64,N)]
              )
              samp_rate=Rs*Sps
              EsN0dB=np.linspace(EsN0min,EsN0max,N)
              EsN0=pow(10.,EsN0dB/10.) 
              self.SNR=EsN0*Rs/samp_rate
              
              
          def work(self, input_items, output_items):
              L=len(input_items[0]) # la entrada en una matrix de L filas y N columnas
              SNR_matrix=np.array([self.SNR]*L) # convertimos SNR a matrix
              P_s=np.mean(np.absolute(input_items[0])**2)  # La potencia de la senal
              P_n = P_s/SNR_matrix                    # la potencia del ruido
              output_items[0][:] = input_items[0]+noise_c(np.sqrt(P_n))
              #output_items[0][:] = input_items[0]*1.5
              return len(output_items[0])
              
      def noise_c(Vrms):
          # random.normal() pide la desviacion standard pero es el mismo Valor RMS
          # Vrms es el Valor RMS de la Envolvente compleja del ruido, pero la vamos
          # a generar como un ruido real mas un ruido imaginario. Pero esas dos
          # senales tienen un valor RMS un tanto diferente: Vrms_q=Vrms/math.sqrt(2.)
          Vrms_q= Vrms/math.sqrt(2.)
          n= np.random.normal(0.,Vrms_q)+np.random.normal(0.,Vrms_q)*1.j
          return n 
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_bercurve_sink_0
  id: qtgui_bercurve_sink
  parameters:
    berlimit: '-7.0'
    berminerrors: '100'
    esno: numpy.linspace(EsN0min, EsN0max, N_snr)
    label1: BPSK mio
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: TX0
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: RX0
  states: {}
- name: vs0_1
  id: virtual_sink
  parameters:
    stream_id: TX0
  states: {}
- name: vs1_0_0
  id: virtual_sink
  parameters:
    stream_id: RX0
  states: {}

connections:
- [analog_random_source_x_1, '0', digital_chunks_to_symbols_xx_1, '0']
- [analog_random_source_x_1, '0', vs0_1, '0']
- [blocks_stream_demux_0, '0', qtgui_bercurve_sink_0, '0']
- [blocks_stream_demux_0, '1', qtgui_bercurve_sink_0, '2']
- [blocks_stream_demux_0, '10', qtgui_bercurve_sink_0, '20']
- [blocks_stream_demux_0, '11', qtgui_bercurve_sink_0, '22']
- [blocks_stream_demux_0, '12', qtgui_bercurve_sink_0, '24']
- [blocks_stream_demux_0, '13', qtgui_bercurve_sink_0, '26']
- [blocks_stream_demux_0, '14', qtgui_bercurve_sink_0, '28']
- [blocks_stream_demux_0, '15', qtgui_bercurve_sink_0, '30']
- [blocks_stream_demux_0, '16', qtgui_bercurve_sink_0, '32']
- [blocks_stream_demux_0, '17', qtgui_bercurve_sink_0, '34']
- [blocks_stream_demux_0, '18', qtgui_bercurve_sink_0, '36']
- [blocks_stream_demux_0, '19', qtgui_bercurve_sink_0, '38']
- [blocks_stream_demux_0, '2', qtgui_bercurve_sink_0, '4']
- [blocks_stream_demux_0, '20', qtgui_bercurve_sink_0, '40']
- [blocks_stream_demux_0, '21', qtgui_bercurve_sink_0, '42']
- [blocks_stream_demux_0, '22', qtgui_bercurve_sink_0, '44']
- [blocks_stream_demux_0, '23', qtgui_bercurve_sink_0, '46']
- [blocks_stream_demux_0, '24', qtgui_bercurve_sink_0, '48']
- [blocks_stream_demux_0, '25', qtgui_bercurve_sink_0, '50']
- [blocks_stream_demux_0, '26', qtgui_bercurve_sink_0, '52']
- [blocks_stream_demux_0, '27', qtgui_bercurve_sink_0, '54']
- [blocks_stream_demux_0, '28', qtgui_bercurve_sink_0, '56']
- [blocks_stream_demux_0, '29', qtgui_bercurve_sink_0, '58']
- [blocks_stream_demux_0, '3', qtgui_bercurve_sink_0, '6']
- [blocks_stream_demux_0, '30', qtgui_bercurve_sink_0, '60']
- [blocks_stream_demux_0, '31', qtgui_bercurve_sink_0, '62']
- [blocks_stream_demux_0, '4', qtgui_bercurve_sink_0, '8']
- [blocks_stream_demux_0, '5', qtgui_bercurve_sink_0, '10']
- [blocks_stream_demux_0, '6', qtgui_bercurve_sink_0, '12']
- [blocks_stream_demux_0, '7', qtgui_bercurve_sink_0, '14']
- [blocks_stream_demux_0, '8', qtgui_bercurve_sink_0, '16']
- [blocks_stream_demux_0, '9', qtgui_bercurve_sink_0, '18']
- [blocks_stream_demux_0_0, '0', qtgui_bercurve_sink_0, '1']
- [blocks_stream_demux_0_0, '1', qtgui_bercurve_sink_0, '3']
- [blocks_stream_demux_0_0, '10', qtgui_bercurve_sink_0, '21']
- [blocks_stream_demux_0_0, '11', qtgui_bercurve_sink_0, '23']
- [blocks_stream_demux_0_0, '12', qtgui_bercurve_sink_0, '25']
- [blocks_stream_demux_0_0, '13', qtgui_bercurve_sink_0, '27']
- [blocks_stream_demux_0_0, '14', qtgui_bercurve_sink_0, '29']
- [blocks_stream_demux_0_0, '15', qtgui_bercurve_sink_0, '31']
- [blocks_stream_demux_0_0, '16', qtgui_bercurve_sink_0, '33']
- [blocks_stream_demux_0_0, '17', qtgui_bercurve_sink_0, '35']
- [blocks_stream_demux_0_0, '18', qtgui_bercurve_sink_0, '37']
- [blocks_stream_demux_0_0, '19', qtgui_bercurve_sink_0, '39']
- [blocks_stream_demux_0_0, '2', qtgui_bercurve_sink_0, '5']
- [blocks_stream_demux_0_0, '20', qtgui_bercurve_sink_0, '41']
- [blocks_stream_demux_0_0, '21', qtgui_bercurve_sink_0, '43']
- [blocks_stream_demux_0_0, '22', qtgui_bercurve_sink_0, '45']
- [blocks_stream_demux_0_0, '23', qtgui_bercurve_sink_0, '47']
- [blocks_stream_demux_0_0, '24', qtgui_bercurve_sink_0, '49']
- [blocks_stream_demux_0_0, '25', qtgui_bercurve_sink_0, '51']
- [blocks_stream_demux_0_0, '26', qtgui_bercurve_sink_0, '53']
- [blocks_stream_demux_0_0, '27', qtgui_bercurve_sink_0, '55']
- [blocks_stream_demux_0_0, '28', qtgui_bercurve_sink_0, '57']
- [blocks_stream_demux_0_0, '29', qtgui_bercurve_sink_0, '59']
- [blocks_stream_demux_0_0, '3', qtgui_bercurve_sink_0, '7']
- [blocks_stream_demux_0_0, '30', qtgui_bercurve_sink_0, '61']
- [blocks_stream_demux_0_0, '31', qtgui_bercurve_sink_0, '63']
- [blocks_stream_demux_0_0, '4', qtgui_bercurve_sink_0, '9']
- [blocks_stream_demux_0_0, '5', qtgui_bercurve_sink_0, '11']
- [blocks_stream_demux_0_0, '6', qtgui_bercurve_sink_0, '13']
- [blocks_stream_demux_0_0, '7', qtgui_bercurve_sink_0, '15']
- [blocks_stream_demux_0_0, '8', qtgui_bercurve_sink_0, '17']
- [blocks_stream_demux_0_0, '9', qtgui_bercurve_sink_0, '19']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_vector_to_stream_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', blocks_stream_to_vector_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', blocks_null_sink_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', vs1_0_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [virtual_source_0, '0', blocks_stream_demux_0, '0']
- [virtual_source_0_0, '0', blocks_stream_demux_0_0, '0']

metadata:
  file_format: 1
