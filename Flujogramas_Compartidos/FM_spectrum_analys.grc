<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Am</value></param>
<param><key>value</key><value>1.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>B</value></param>
<param><key>value</key><value>2*DeltaF3+2*fm</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DeltaF1</value></param>
<param><key>value</key><value>beta1*fm</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DeltaF2</value></param>
<param><key>value</key><value>beta2*fm</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DeltaF3</value></param>
<param><key>value</key><value>beta3*fm</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DeltaF4</value></param>
<param><key>value</key><value>beta4*fm</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kf1</value></param>
<param><key>value</key><value>DeltaF1/Am</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kf2</value></param>
<param><key>value</key><value>DeltaF2/Am</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kf3</value></param>
<param><key>value</key><value>DeltaF3/Am</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kf4</value></param>
<param><key>value</key><value>DeltaF4/Am</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>beta1</value></param>
<param><key>value</key><value>1.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>beta2</value></param>
<param><key>value</key><value>2.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>beta3</value></param>
<param><key>value</key><value>5.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>beta4</value></param>
<param><key>value</key><value>10.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm</value></param>
<param><key>value</key><value>1000.</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>64000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>Am</value></param>
<param><key>freq</key><value>fm</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>b_PSD_c</key>
<param><key>id</key><value>b_PSD_c_0</value></param>
<param><key>Fc</key><value>0</value></param>
<param><key>samp_rate_audio</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Titulo</key><value>'beta=5'</value></param>
<param><key>Ymax</key><value>0.0002</value></param>
</block>
<block>
<key>b_PSD_c</key>
<param><key>id</key><value>b_PSD_c_0_0</value></param>
<param><key>Fc</key><value>0</value></param>
<param><key>samp_rate_audio</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Titulo</key><value>'beta=2'</value></param>
<param><key>Ymax</key><value>0.0004</value></param>
</block>
<block>
<key>b_PSD_c</key>
<param><key>id</key><value>b_PSD_c_0_1</value></param>
<param><key>Fc</key><value>0</value></param>
<param><key>samp_rate_audio</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Titulo</key><value>'beta=1'</value></param>
<param><key>Ymax</key><value>0.0006</value></param>
</block>
<block>
<key>b_PSD_c</key>
<param><key>id</key><value>b_PSD_c_0_2</value></param>
<param><key>Fc</key><value>0</value></param>
<param><key>samp_rate_audio</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Titulo</key><value>'beta=10'</value></param>
<param><key>Ymax</key><value>0.0002</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>Kf1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>Kf2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>Kf3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0</value></param>
<param><key>const</key><value>Kf4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensitivity</key><value>2*math.pi</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensitivity</key><value>2*math.pi</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_0_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensitivity</key><value>2*math.pi</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_0_0_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensitivity</key><value>2*math.pi</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs</value></param>
<param><key>stream_id</key><value>P1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs_0</value></param>
<param><key>stream_id</key><value>P2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs_0_0</value></param>
<param><key>stream_id</key><value>P3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs_0_0_0</value></param>
<param><key>stream_id</key><value>P4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso</value></param>
<param><key>stream_id</key><value>P1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso_0</value></param>
<param><key>stream_id</key><value>P2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso_0_0</value></param>
<param><key>stream_id</key><value>P3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso_0_0_0</value></param>
<param><key>stream_id</key><value>P4</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_vco_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_vco_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_vco_c_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>blocks_vco_c_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>vs</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_0</source_block_id><sink_block_id>vs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_0_0</source_block_id><sink_block_id>vs_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_0_0_0</source_block_id><sink_block_id>vs_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso</source_block_id><sink_block_id>b_PSD_c_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso_0</source_block_id><sink_block_id>b_PSD_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso_0_0</source_block_id><sink_block_id>b_PSD_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso_0_0_0</source_block_id><sink_block_id>b_PSD_c_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
