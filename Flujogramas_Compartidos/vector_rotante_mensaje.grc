options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: F
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Frecuencia
    orient: Qt.Horizontal
    start: '-samp_rate/256.'
    step: (2*samp_rate/256.)/1024.
    stop: samp_rate/256.
    value: '0'
  states: {}
- name: Kd
  id: variable
  parameters:
    value: '128'
  states: {}
- name: Kd_2
  id: variable
  parameters:
    value: '16'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: F
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 1./2
    freq: 1./64
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Ac: '1.0'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  
          """Done by Homero Ortega Boada"""

          def __init__(self, samp_rate=200000., Ac=1.):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='e_VCO_frec_fc',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.complex64]
              )
              self.samp_rate = float(samp_rate)
              self.Ac = Ac
              self.last_t=0.

          def work(self, input_items, output_items):
              in0=input_items[0]
              out0=output_items[0]
              L=len(in0)
              t=np.arange(L)/self.samp_rate+self.last_t
              theta=2.*np.pi*in0*t
              out0[:] = self.Ac*np.exp(1.j*theta)
              self.last_t += L/self.samp_rate
              return len(out0)
    samp_rate: samp_rate
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2,0,1,1
    label1: '''                                                                                                                        .'''
    size: '10'
    type: complex
    update_time: '0.001'
    width1: '4'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1,1,1,1
    label1: ''
    label2: ''
    size: '1024'
    srate: (samp_rate/Kd)
    type: complex
    update_time: '0.001'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: ''
    size: '1024'
    srate: (samp_rate/Kd)
    type: float
    update_time: '0.001'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Kd
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: Kd
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: Kd_2
    interp: '1'
    taps: ''
    type: fff
  states: {state: disabled}
- name: vs
  id: virtual_sink
  parameters:
    stream_id: P1
  states: {}
- name: vs_0
  id: virtual_sink
  parameters:
    stream_id: P2
  states: {}
- name: vso
  id: virtual_source
  parameters:
    stream_id: P1
  states: {}
- name: vso_0
  id: virtual_source
  parameters:
    stream_id: P2
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [analog_sig_source_x_0, '0', vs_0, '0']
- [blocks_throttle_0, '0', vs, '0']
- [epy_block_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [vso, '0', rational_resampler_xxx_0, '0']
- [vso_0, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
