<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Lab_total</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Ajuste_phi</value></param>
<param><key>value</key><value>0.</value></param>
<param><key>gui_hint</key><value>controls@0:0,2,1,1</value></param>
<param><key>label</key><value>Ch_Desajuste_phi (Rad)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-2.*math.pi</value></param>
<param><key>step</key><value>4*math.pi/200.</value></param>
<param><key>stop</key><value>2.*math.pi</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bps</value></param>
<param><key>value</key><value>int(math.log(M,2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ch_Fluct_percent</value></param>
<param><key>value</key><value>10.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>value</key><value>MiconstellationObject.points()</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>F_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@0:0,1,1,1</value></param>
<param><key>label</key><value>Ch_Frec_offset (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fc</value></param>
<param><key>value</key><value>80e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kd</value></param>
<param><key>value</key><value>math.pow(2,m1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kd_d</value></param>
<param><key>value</key><value>samp_rate_usrp_rx/samp_rate_d</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ki</value></param>
<param><key>value</key><value>math.pow(2,m)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ki_d</value></param>
<param><key>value</key><value>samp_rate_usrp_tx/samp_rate_d</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>len(Constelacion)</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>MiconstellationObject</value></param>
<param><key>const_points</key><value>digital.constellation_8psk().points()</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value></value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NbpS</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NnivelesQ</value></param>
<param><key>value</key><value>math.pow(2,NbpS)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>NodB</value></param>
<param><key>value</key><value>-60.</value></param>
<param><key>gui_hint</key><value>controls@0:0,3,1,1</value></param>
<param><key>label</key><value>Ch Noise dB</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Path_Loss_dB</value></param>
<param><key>value</key><value>0.</value></param>
<param><key>gui_hint</key><value>controls@0:0,4,1,1</value></param>
<param><key>label</key><value>Ch_Path_Loss_dB</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>value</key><value>NbpS*samp_rate_audio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>Rb/Bps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>SymbTune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@1:0,0,1,1</value></param>
<param><key>label</key><value>SymbTunning</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Tmax_scope</value></param>
<param><key>value</key><value>16./Rs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vp</value></param>
<param><key>value</key><value>1.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>m</value></param>
<param><key>value</key><value>math.floor(math.log(Ki_d,2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>m1</value></param>
<param><key>value</key><value>math.floor(math.log(Kd_d,2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mapdirect</value></param>
<param><key>value</key><value>coding.direct_map(Constelacion)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mapinverse</value></param>
<param><key>value</key><value>coding.inverse_map(Constelacion)</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(samp_rate_usrp_rx/Kd)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_audio</value></param>
<param><key>value</key><value>11000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_d</value></param>
<param><key>value</key><value>Rs*Sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_tx</value></param>
<param><key>value</key><value>int(samp_rate_usrp_tx/Ki)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_usrp_rx</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_usrp_tx</value></param>
<param><key>value</key><value>400e6</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0</value></param>
<param><key>stream_id</key><value>T8</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0</value></param>
<param><key>stream_id</key><value>T7</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_0</value></param>
<param><key>stream_id</key><value>R8</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_1</value></param>
<param><key>stream_id</key><value>R7</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_1_0</value></param>
<param><key>stream_id</key><value>R4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_1_0_0</value></param>
<param><key>stream_id</key><value>R3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_1_0_0_0</value></param>
<param><key>stream_id</key><value>R2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_2</value></param>
<param><key>stream_id</key><value>T4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_2_0</value></param>
<param><key>stream_id</key><value>T3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_2_0_0</value></param>
<param><key>stream_id</key><value>T2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_3</value></param>
<param><key>stream_id</key><value>T1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_3_0</value></param>
<param><key>stream_id</key><value>R1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_3_0_0</value></param>
<param><key>stream_id</key><value>R0</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
</block>
<block>
<key>b_Canal_simple_cc</key>
<param><key>id</key><value>b_Canal_simple_cc_0</value></param>
<param><key>Ch_NodB</key><value>NodB</value></param>
<param><key>Ch_Loss_dB</key><value>Path_Loss_dB</value></param>
<param><key>Ch_Phoffset</key><value>Ajuste_phi</value></param>
<param><key>Ch_Toffset</key><value>0</value></param>
<param><key>Fluctuacion</key><value>Ch_Fluct_percent</value></param>
<param><key>Foffset</key><value>F_offset</value></param>
<param><key>T_fluct</key><value>M*1024</value></param>
<param><key>samp_rate</key><value>Rs</value></param>
</block>
<block>
<key>b_quantizer_fb</key>
<param><key>id</key><value>b_quantizer_fb_0</value></param>
<param><key>NivelesQ</key><value>NnivelesQ</value></param>
<param><key>Vmax</key><value>Vp</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>SymbTune</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>Vp/(NnivelesQ/2)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>Bps</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>Bps</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/uis-e3t/MisGits/comdig_pract_M_PSK/bush-clinton_debate_waffle.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>canal</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label0</key><value>Constelaciones</value></param>
<param><key>label1</key><value>Tiempo</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>coding</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
import numpy
import math
#######################################################
##        Done by Homero Ortega Boada              ##
##        comdiguis@saber.uis.edu.co                 ##
##     Universidad Industrial de Santander           ##
#######################################################
#######################################################
##       Constellation map  identification           ##
#######################################################                  
# Constellation points are analyzed to determine the 
# the map used for ordering of the constellation points
def sum_modulus(a,b,modulus):
    # realiza una suma de a y b en modulo modulus
    return (a+b)%modulus

def angle_map(constellation_points):
    # esta funcion entrega todos los angulos positivos entre 0 y 2pi
    angles=numpy.angle(constellation_points)
    return sum_modulus(angles, 2*math.pi, 2*math.pi)

def inverse_map(constellation_points):
    M=len(constellation_points)
    angles=angle_map(constellation_points)
    angles=sum_modulus(angles,-angles[0], 2*math.pi) # giro a agulo cero
    delta_angle= 2*math.pi/M     # angulo entre puntos
    cod_inv=numpy.round(angles/delta_angle)
    cod_inv=cod_inv.astype(numpy.int) #conversion a entero 
    return cod_inv

def direct_map(constellation_points):
    M=len(constellation_points)
    codinv=inverse_map(constellation_points)
    coddirect=numpy.array([0]*M)
    for j in range(M):
        temp=numpy.where(codinv==j)
        coddirect[j]=temp[0][0]
    return coddirect

""" # SECCION DE PRUEBAS DEL CODIGO
import gnuradio.digital as digital
constelacion=digital.constellation_8psk().points()
print("constelacion = ", constelacion)
mapdirect=direct_map(constelacion)
print("codigo directo = ", mapdirect)
mapinverse=inverse_map(constelacion)
print("codigo inverso = ", mapinverse)
"""






</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>controls</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>label0</key><value>Manipulacion parametros del Canal</value></param>
<param><key>label1</key><value>Sintonizar parametros de otros bloques</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>Constelacion</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>MiconstellationObject</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>M</value></param>
</block>
<block>
<key>digital_diff_encoder_bb</key>
<param><key>id</key><value>digital_diff_encoder_bb_0</value></param>
<param><key>modulus</key><value>M</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0</value></param>
<param><key>map</key><value>mapdirect</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0_0</value></param>
<param><key>map</key><value>mapinverse</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_1_0_0_0</value></param>
<param><key>stream_id</key><value>R0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_1_1</value></param>
<param><key>stream_id</key><value>T1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>CAPA8 MENSAJE</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>CAPA7 CUANTIFICACION</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>note</key><value>CAPA3 M-PAM</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0</value></param>
<param><key>note</key><value>CAPA3 COD DIF</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0</value></param>
<param><key>note</key><value>CAPA1 MODULACION EC</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_1</value></param>
<param><key>note</key><value>CAPA2 MAP</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_1</value></param>
<param><key>note</key><value>CAPA0 CANAL</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_1_2</value></param>
<param><key>note</key><value>INSTRUMENTACION</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>SIGLAS Y VARIABLES: https://docs.google.com/document/d/19AjAUNqbtj1wffUuGf1V54hHX_k6hvU3wvFGbyFYviE/edit#bookmark=id.mnniv0n51crf</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_2_0</value></param>
<param><key>gui_hint</key><value>canal@0:2,0,1,1</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>"Tx.Modulador-salida                                                             "</value></param>
<param><key>width1</key><value>4</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>2.0</value></param>
<param><key>xmin</key><value>-2.0</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_2_0_0</value></param>
<param><key>gui_hint</key><value>canal@0:1,0,1,1</value></param>
<param><key>color1</key><value>"green"</value></param>
<param><key>label1</key><value>"Salida del canal                                                                         "</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>2.0</value></param>
<param><key>xmin</key><value>-2.0</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>canal@1:1,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Nivel de potencia RF (dB)"</value></param>
<param><key>size</key><value>int(2.5*samp_rate)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>40</value></param>
<param><key>ymin</key><value>-40</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>T4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>R4</value></param>
</block>
<connection><source_block_id>b_Canal_simple_cc_0</source_block_id><sink_block_id>Tx_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_Canal_simple_cc_0</source_block_id><sink_block_id>Tx_3_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_Canal_simple_cc_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_quantizer_fb_0</source_block_id><sink_block_id>Tx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_quantizer_fb_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>Tx_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>Tx_1_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>Tx_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>Tx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>b_quantizer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>Tx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>b_Canal_simple_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>Tx_1_0_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>digital_map_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>Tx_1_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_encoder_bb_0</source_block_id><sink_block_id>Tx_1_0_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_encoder_bb_0</source_block_id><sink_block_id>digital_map_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0</source_block_id><sink_block_id>Tx_1_0_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0_0</source_block_id><sink_block_id>Tx_1_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_1</source_block_id><sink_block_id>qtgui_const_sink_x_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>digital_diff_encoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
