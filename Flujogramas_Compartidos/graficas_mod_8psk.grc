options:
  parameters:
    author: Homero Ortega Boada
    category: Custom
    description: Sps2, Rs2, Rb2  sido introducido con el fin de obtener una PSD sin tantos lobulos. Lo que hicimos es un sistema con dos salidas a diferentes velocidades
    generate_options: qt_gui
    id: Lab_total
    output_language: python
    run: run_stop
    title: Lab_total
  states: {}

blocks:
- name: Bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Kd
  id: variable
  parameters:
    value: '8'
  states: {}
- name: M
  id: variable
  parameters:
    value: len(MiconstellationObject.points())
  states: {}
- name: MiconstellationObject
  id: variable_constellation
  parameters:
    const_points: const[2].points()
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: numpy.arange(len(const[2].points()))
    type: calcdist
  states: {}
- name: Nfdev
  id: variable
  parameters:
    value: '32'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*Bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '64'
  states: {}
- name: const
  id: variable
  parameters:
    value: (digital.constellation_bpsk(), digital.constellation_qpsk(), digital.constellation_8psk(), digital.qam.qam_constellation(16))
  states: {}
- name: const_0
  id: variable
  parameters:
    value: (digital.constellation_bpsk(), digital.constellation_qpsk(), digital.constellation_8psk(), digital.qam.qam_constellation(16))
  states: {}
- name: f_dev
  id: variable
  parameters:
    value: numpy.linspace(-f_dev_max,f_dev_max,Nfdev+1 )
  states: {}
- name: f_dev_max
  id: variable
  parameters:
    value: 1/10.
  states: {}
- name: mod
  id: variable
  parameters:
    value: str(M)+"PSK"
  states: {}
- name: pam
  id: variable
  parameters:
    value: str(M)+"PAM"
  states: {}
- name: puntos
  id: variable
  parameters:
    value: MiconstellationObject.points()
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: E3TRadio_Zero_Order_Hold_0
  id: E3TRadio_Zero_Order_Hold
  parameters:
    k: Sps
  states: {}
- name: E3TRadio_Zero_Order_Hold_0_0
  id: E3TRadio_Zero_Order_Hold
  parameters:
    k: int(Sps/Bps)
  states: {}
- name: E3TRadio_zero_order_hold2_cc_0
  id: E3TRadio_zero_order_hold2_cc
  parameters:
    k: Sps
  states: {}
- name: E3TRadio_zero_order_hold2_cc_0_0
  id: E3TRadio_zero_order_hold2_cc
  parameters:
    k: int(Sps/Kd)
  states: {}
- name: M_PAM
  id: virtual_sink
  parameters:
    stream_id: M_PAM
  states: {}
- name: M_PAM_0
  id: virtual_sink
  parameters:
    stream_id: PCM
  states: {}
- name: M_PAM_0_0
  id: virtual_sink
  parameters:
    stream_id: pasobanda
  states: {}
- name: M_PAM_1
  id: virtual_sink
  parameters:
    stream_id: Modulada_d
  states: {}
- name: M_PAM_1_0
  id: virtual_sink
  parameters:
    stream_id: Modulada_cont
  states: {}
- name: b_symb_source_0
  id: b_symb_source
  parameters:
    Constelacion: MiconstellationObject.points()
  states: {}
- name: b_upconverter_cf_0
  id: b_upconverter_cf
  parameters:
    Fc: Rs*2
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '7'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '4.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '3'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '3'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/2.
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2./M
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: Rb
    type: float
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: Bps
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: MiconstellationObject.points()
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from random import randint, uniform
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import  numpy
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import random
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 4,0,1,1
    label1: mod+"                                                                                         ."
    size: '1024'
    type: complex
    width1: '6'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate/Kd
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1,1,1
    label1: mod
    name: mod+", Rs=1,5625 kBaud, Rb=4,6875 kbps"
    showports: 'True'
    type: complex
    width1: '3'
    ymax: '-20'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,3,1
    label1: PCM
    label2: pam
    label3: mod+". EC. Re"
    label4: mod+". EC. Im"
    label5: mod+" Pasobandas"
    name: ''
    nconnections: '5'
    size: Sps*8
    srate: samp_rate
    type: float
    width1: '4'
    width2: '4'
    width3: '4'
    width4: '4'
    width5: '4'
    ymax: '8'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,1,2,1
    label1: pam
    label2: mod+". EC. Re"
    label3: mod+". EC. Im"
    marker1: '0'
    marker2: '0'
    marker3: '3'
    name: ''
    nconnections: '3'
    size: '8'
    srate: Rs
    type: float
    width1: '4'
    width2: '4'
    width3: '4'
    ymax: '4.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1,1,1
    label1: '"PCM               ."'
    marker1: '0'
    name: ''
    size: 8*Bps
    srate: Rb
    type: float
    width1: '4'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: PCM
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Modulada_d
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Modulada_cont
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: pasobanda
  states: {}
- name: virtual_source_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: Modulada_d
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: M_PAM
  states: {}

connections:
- [E3TRadio_Zero_Order_Hold_0, '0', blocks_add_const_vxx_0_0, '0']
- [E3TRadio_Zero_Order_Hold_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [E3TRadio_zero_order_hold2_cc_0, '0', M_PAM_1_0, '0']
- [E3TRadio_zero_order_hold2_cc_0, '0', b_upconverter_cf_0, '0']
- [E3TRadio_zero_order_hold2_cc_0_0, '0', qtgui_freq_sink_x_0, '0']
- [b_symb_source_0, '0', E3TRadio_zero_order_hold2_cc_0, '0']
- [b_symb_source_0, '0', M_PAM_1, '0']
- [b_symb_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [b_upconverter_cf_0, '0', M_PAM_0_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0_1_0, '1']
- [blocks_add_const_vxx_0_0_0, '0', qtgui_time_sink_x_0_1_0, '2']
- [blocks_add_const_vxx_0_0_0_0, '0', qtgui_time_sink_x_0_1_0, '3']
- [blocks_add_const_vxx_0_0_0_0_0, '0', qtgui_time_sink_x_0_1_0_0, '2']
- [blocks_add_const_vxx_0_0_0_1, '0', qtgui_time_sink_x_0_1_0_0, '1']
- [blocks_add_const_vxx_0_0_1, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_char_to_float_0_0, '0', E3TRadio_Zero_Order_Hold_0_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_1_0_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_complex_to_float_0, '1', blocks_add_const_vxx_0_0_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_add_const_vxx_0_0_0_1, '0']
- [blocks_complex_to_float_0_0, '1', blocks_add_const_vxx_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_1_0, '4']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', E3TRadio_Zero_Order_Hold_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_const_vxx_0_0_1, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_1_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', M_PAM_0, '0']
- [blocks_vector_source_x_0, '0', E3TRadio_zero_order_hold2_cc_0, '0']
- [blocks_vector_source_x_0, '0', M_PAM_1, '0']
- [blocks_vector_source_x_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_constellation_decoder_cb_0, '0', M_PAM, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [virtual_source_0_0, '0', blocks_char_to_float_0_0, '0']
- [virtual_source_0_0_0, '0', E3TRadio_zero_order_hold2_cc_0_0, '0']
- [virtual_source_0_0_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_complex_to_float_0, '0']
- [virtual_source_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [virtual_source_0_0_0_0_1, '0', blocks_complex_to_float_0_0, '0']
- [virtual_source_0_0_1, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
