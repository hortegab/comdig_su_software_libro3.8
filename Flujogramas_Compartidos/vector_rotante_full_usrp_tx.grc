options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: A
    orient: Qt.Horizontal
    start: '-1.5'
    step: (1.5)/100.
    stop: '1.5'
    value: '1.'
  states: {}
- name: Ar
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Ruido
    orient: Qt.Horizontal
    start: '0'
    step: (4.)/50.
    stop: '4.'
    value: '0.'
  states: {}
- name: F
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Frecuencia
    orient: Qt.Horizontal
    start: '-2.4'
    step: (2*2.4)/1000.
    stop: '2.4'
    value: '0.'
  states: {}
- name: Fc
  id: variable
  parameters:
    value: '88000000'
  states: {}
- name: Kd
  id: variable
  parameters:
    value: '128'
  states: {}
- name: P
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Fase
    orient: Qt.Horizontal
    start: '-2.*math.pi'
    step: (4.*math.pi)/360.
    stop: 2.*math.pi
    value: '0.'
  states: {}
- name: Tupdate
  id: variable
  parameters:
    value: 1./100.
  states: {}
- name: r
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: samp_rate_out
  id: variable
  parameters:
    value: samp_rate/Kd
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: F
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: P
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: A
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*math.pi/samp_rate
    type: float
  states: {}
- name: e_VCO_fase_fc_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  \n    \"\"\"Done by Homero Ortega Boada. Es un VCO dos entradas: \nin0 para manipular la fase, in1 para manipular la \nmagnitud. En el fondo es el equivalente a un generador\nde una senal exponencial compleja. Sobre la configuracion:\ncada valor de la senal en in0 es interpretada como la fase\ndeseada en radianes. cada valor de in0, es la magnitud deseada\"\"\"\n\n    def __init__(self): \n        gr.sync_block.__init__(self,\n            name='e_VCO_fase_fc',\n            in_sig=[np.float32, np.float32],\n            out_sig=[np.complex64]\n        )\n    def work(self, input_items, output_items):\n        in0=input_items[0]\n        in1=input_items[1]\n        out0=output_items[0]\n        out0[:] = in1*np.exp(1.j*in0)\n        return len(out0)\n"
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Hecho por Homoero Ortega. Es un acumulador puro, va acumulando cada muestra entrante mientras entrega lo que lleva acumulado hasta el momento. Puede convertirse en un integrador si la salida se divide en la frecuencia de muestreo de la senal"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='e_Accum_ff',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.memory=0.

          def work(self, input_items, output_items):
              """El acumulador"""
              in0=input_items[0]
              out0=output_items[0]
              L=len(in0)
              out0[:]=(self.memory+np.cumsum(in0))
              self.memory=out0[L-1]
              return len(out0)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: menu
  id: qtgui_tab_widget
  parameters:
    label0: Transmisor
    label1: Receptor
    num_tabs: '2'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: menu@0:4,0,1,1
    label1: '''.'''
    name: ''
    size: '8'
    type: complex
    update_time: Tupdate
    width1: '4'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@0:4,1,1,2
    label1: Re
    label2: Im
    name: '"Senal Modulada"'
    size: '1024'
    srate: (samp_rate/Kd)
    type: complex
    update_time: Tupdate
    width1: '3'
    width2: '3'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@0:3,2,1,1
    label1: '''.'''
    name: '"Nivel de frecuencia"'
    size: '1024'
    srate: (samp_rate/Kd)
    type: float
    update_time: Tupdate
    width1: '3'
    ylabel: Frecuencia
    ymax: '2.5'
    ymin: '-2.5'
    yunit: Hz
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@0:3,1,1,1
    label1: '''.'''
    name: '"Nivel de Fase"'
    size: '1024'
    srate: (samp_rate/Kd)
    type: float
    update_time: Tupdate
    width1: '3'
    ylabel: Fase
    ymax: 2*math.pi
    ymin: '-2*math.pi'
    yunit: radianes
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@0:3,0,1,1
    label1: '''.'''
    name: '"Nivel de Amplitud"'
    size: '1024'
    srate: (samp_rate/Kd)
    type: float
    update_time: Tupdate
    width1: '3'
    ylabel: Amplitud
    ymax: '1.5'
    ymin: '-1.5'
    yunit: volts
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Kd
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: Kd
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: Kd
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: Kd
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: '390625'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: Fc
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: vs
  id: virtual_sink
  parameters:
    stream_id: P1
  states: {}
- name: vs_0
  id: virtual_sink
  parameters:
    stream_id: P2
  states: {}
- name: vs_0_0
  id: virtual_sink
  parameters:
    stream_id: P2a
  states: {}
- name: vs_0_0_0
  id: virtual_sink
  parameters:
    stream_id: P2b
  states: {}
- name: vso
  id: virtual_source
  parameters:
    stream_id: P1
  states: {}
- name: vso_0
  id: virtual_source
  parameters:
    stream_id: P2
  states: {}
- name: vso_0_0
  id: virtual_source
  parameters:
    stream_id: P2a
  states: {}
- name: vso_0_0_0
  id: virtual_source
  parameters:
    stream_id: P2b
  states: {}

connections:
- [analog_const_source_x_0, '0', epy_block_0, '0']
- [analog_const_source_x_0, '0', vs_0, '0']
- [analog_const_source_x_0_0, '0', blocks_add_xx_0, '1']
- [analog_const_source_x_0_0, '0', vs_0_0, '0']
- [analog_const_source_x_0_0_0, '0', e_VCO_fase_fc_0, '1']
- [analog_const_source_x_0_0_0, '0', vs_0_0_0, '0']
- [blocks_add_xx_0, '0', e_VCO_fase_fc_0, '0']
- [blocks_multiply_const_vxx_0_0_0_1_0_0, '0', blocks_add_xx_0, '0']
- [e_VCO_fase_fc_0, '0', rational_resampler_xxx_1, '0']
- [e_VCO_fase_fc_0, '0', vs, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_0_0_0_1_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [rational_resampler_xxx_1, '0', uhd_usrp_sink_0, '0']
- [vso, '0', rational_resampler_xxx_0, '0']
- [vso_0, '0', rational_resampler_xxx_0_0, '0']
- [vso_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [vso_0_0_0, '0', rational_resampler_xxx_0_0_0_0, '0']

metadata:
  file_format: 1
